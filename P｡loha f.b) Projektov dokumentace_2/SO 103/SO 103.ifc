Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [Ifc4X3NotAssigned]
File name: D:\_Projekty\2017_07 - SÚS Obchvat Dašic\4_PDPS\BIM\IFC\SO 103.ifc
Time: 2025-03-05T12:07:57
Author: Michal Švarc
Organization: DESKTOP-47J51D1
Written by: GeometryGymIFCcore v24.8.23.0 by Geometry Gym Pty Ltd built 2024-08-23T03:53:20
Made in: Civil 3D 2024 IfcInfra Plugin v13.6.170.0
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcProject, SO 103
Summary - Title: CAD Studio Silniční šablona; Author: Martin Folber, Ondřej Vojtěchovský, Jakub Kareš; HyperlinkBase: www.cadstudio.cz
Custom_Properties - Souřadnicový systém: S-JTSK; Výškový systém: Bpv

# IfcBuiltElement (81)
In: UnknownName
Properties - ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: no; IsModifiedGraphics: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no; CloneMeForDragging: yes; IsNull: no; UsesGraphicsCache: yes
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
General - Linetype: ByLayer; LinetypeScale: 1; Visible: yes
Geometry - IsPlanar: no
CZ_E1 - Datum zahájení prací: 01.05.2025; Datum dokončení: 30.06.2027; Doba trvání: 790; Datum uvedení do provozu: 01.07.2027; Stavební postup / etapa výstavby: nerelevantni
CZ_F1 - Fáze: trvalý stav
Name | Area | NumChanges | RecordHistory = ShowHistory | Bounds | ColorIndex | Layer | PlotStyleName | Označení stavebního objektu | Označení podobjektu = Označení části objektu | CZ_I1, Fáze projektu | Název stavebního objektu | CZ_I1, Klasifikační systém | CZ_I1, Staničení od | CZ_I1, Staničení do | CZ_I1, Označení elementu | Skupina elementů | CZ_I1, Označení položky | CZ_I1, Označení šablony vlastností | podrobná specifikace | CZ_S1, Reference | Materiál | specifikace | Skupina přesnosti | Textura / barva | Objem | Způsob stanovení objemu | Tloušťka
vozovka_chodník-obrusná vrstva | 307.654 | 1 | no | ((-642737.669273483,-1062731.93410529,232.292391445815),(-642688.663985572,-1062722.0414673,233.124114044926)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.02046 | 0.06949 | obrusná vrstva | vozovka/chodník | 574A03 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | ACO 11 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 6.06701 | řezová metoda | 0.04
vozovka_chodník-obrusná vrstva | 329.617 | 1 | no | ((-642737.206261719,-1062735.61186095,232.288795192544),(-642688.217823272,-1062725.04097693,233.124114044926)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.02046 | 0.06949 | obrusná vrstva | vozovka/chodník | 574A03 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | ACO 11 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 6.50564 | řezová metoda | 0.04
vozovka_chodník-podkladní asfaltová vrstva | 310.785 | 1 | no | ((-642737.669273483,-1062731.93410529,232.222391445815),(-642688.663985572,-1062722.0414673,233.084114044926)) | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.02046 | 0.06949 | podkladní asfaltová vrstva | vozovka/chodník | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 10.6173 | řezová metoda | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 332.766 | 1 | no | ((-642737.206261719,-1062735.61186095,232.218795192544),(-642688.217823272,-1062725.04097693,233.084114044926)) | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.02046 | 0.06949 | podkladní asfaltová vrstva | vozovka/chodník | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 11.3849 | řezová metoda | 0.07
vozovka_chodník-horní podkladní vrstva | 319.136 | 1 | no | ((-642737.669273483,-1062731.93410529,232.072391445815),(-642688.663985572,-1062722.0414673,233.014114044926)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.02046 | 0.06949 | horní podkladní vrstva | vozovka/chodník | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 22.7513 | řezová metoda | 0.15
vozovka_chodník-horní podkladní vrstva | 341.162 | 1 | no | ((-642737.206261719,-1062735.61186095,232.068795192544),(-642688.217823272,-1062725.04097693,233.014114044926)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.02046 | 0.06949 | horní podkladní vrstva | vozovka/chodník | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 24.3961 | řezová metoda | 0.15
vozovka_chodník-spodní podkladní vrstva | 325.184 | 1 | no | ((-642737.669273483,-1062731.93410529,231.857243441563),(-642688.663985572,-1062722.0414673,232.864114044926)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.02046 | 0.06949 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 31.5086 | řezová metoda | 0.2
vozovka_chodník-spodní podkladní vrstva | 347.305 | 1 | no | ((-642737.206261719,-1062735.61186095,231.852927937639),(-642688.217823272,-1062725.04097693,232.864114044926)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.02046 | 0.06949 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 33.8799 | řezová metoda | 0.2
vozovka_chodník-podkladní asfaltová vrstva | 15.9615 | 1 | no | ((-642736.684010934,-1062735.71650734,232.216152787481),(-642688.202963215,-1062728.18290792,232.991247768159)) | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.02046 | 0.06949 | podkladní asfaltová vrstva | vozovka/chodník | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.301933 | řezová metoda | 0.07
vozovka_chodník-zpevnění krajnic | 115.505 | 1 | no | ((-642736.684010934,-1062736.70913692,232.089653246772),(-642688.062007255,-1062728.18290792,233.031247768159)) | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.02046 | 0.06949 | zpevnění krajnic | vozovka/chodník | 56960 | I1+S1+E1+Z1+M3+F1 | nerelevantni | D.1.3.4 | Recyklovaný materiál | VL 1 | P2 | 128;128;128 | 5.95593 | řezová metoda
zemní práce-zemní krajnice a dosypávky | 74.4718 | 1 | no | ((-642736.642679806,-1062736.61414782,231.972797890217),(-642688.076305404,-1062728.47396692,232.857250220375)) | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.02046 | 0.06949 | zemní krajnice a dosypávky | zemní práce | 173103 | I1+S1+E1+Z1+M3+F1 | nerelevantni | D.1.3.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 2.75963 | řezová metoda
vozovka_chodník-obrusná vrstva | 124.082 | 1 | no | ((-642689.089923674,-1062725.04097693,232.201026071744),(-642668.574695901,-1062719.22619746,232.408131467071)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.06949 | 0.08978 | obrusná vrstva | vozovka/chodník | 574A03 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | ACO 11 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 2.44357 | řezová metoda | 0.04
vozovka_chodník-obrusná vrstva | 129.51 | 1 | no | ((-642688.663985572,-1062728.18290792,232.19795028463),(-642668.13678011,-1062722.188246,232.408131467071)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.06949 | 0.08978 | obrusná vrstva | vozovka/chodník | 574A03 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | ACO 11 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 2.55187 | řezová metoda | 0.04
vozovka_chodník-podkladní asfaltová vrstva | 125.48 | 1 | no | ((-642689.089923674,-1062725.04097693,232.131026071744),(-642668.574695901,-1062719.22619746,232.368131467071)) | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.06949 | 0.08978 | podkladní asfaltová vrstva | vozovka/chodník | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 4.27625 | řezová metoda | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 130.916 | 1 | no | ((-642688.663985572,-1062728.18290792,232.12795028463),(-642668.13678011,-1062722.188246,232.368131467071)) | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.06949 | 0.08978 | podkladní asfaltová vrstva | vozovka/chodník | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 4.46578 | řezová metoda | 0.07
vozovka_chodník-horní podkladní vrstva | 129.209 | 1 | no | ((-642689.089923674,-1062725.04097693,231.981026071744),(-642668.574695901,-1062719.22619746,232.298131467071)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.06949 | 0.08978 | horní podkladní vrstva | vozovka/chodník | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 9.16339 | řezová metoda | 0.15
vozovka_chodník-horní podkladní vrstva | 134.666 | 1 | no | ((-642688.663985572,-1062728.18290792,231.97795028463),(-642668.13678011,-1062722.188246,232.298131467071)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.06949 | 0.08978 | horní podkladní vrstva | vozovka/chodník | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 9.56953 | řezová metoda | 0.15
vozovka_chodník-spodní podkladní vrstva | 131.898 | 1 | no | ((-642689.089923674,-1062725.04097693,231.766067252002),(-642668.574695901,-1062719.22619746,232.148131467071)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.06949 | 0.08978 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 12.6777 | řezová metoda | 0.2
vozovka_chodník-spodní podkladní vrstva | 137.386 | 1 | no | ((-642688.663985572,-1062728.18290792,231.762376307465),(-642668.13678011,-1062722.188246,232.148131467071)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.06949 | 0.08978 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 13.2608 | řezová metoda | 0.2
vozovka_chodník-podkladní asfaltová vrstva | 6.61212 | 1 | no | ((-642688.217823272,-1062728.2875543,232.125307879567),(-642668.121920053,-1062725.27210403,232.288795192544)) | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.06949 | 0.08978 | podkladní asfaltová vrstva | vozovka/chodník | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.124956 | řezová metoda | 0.07
vozovka_chodník-horní podkladní vrstva | 21.9363 | 1 | no | ((-642688.217823272,-1062728.61800544,231.966963723723),(-642668.07499514,-1062725.27210403,232.218795192544)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.06949 | 0.08978 | horní podkladní vrstva | vozovka/chodník | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 0.98181 | řezová metoda | 0.15
vozovka_chodník-zpevnění krajnic | 47.9385 | 1 | no | ((-642688.217823272,-1062729.28018389,231.998808338841),(-642667.980964093,-1062725.27210403,232.328795192544)) | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.06949 | 0.08978 | zpevnění krajnic | vozovka/chodník | 56960 | I1+S1+E1+Z1+M3+F1 | nerelevantni | D.1.3.4 | Recyklovaný materiál | VL 1 | P2 | 128;128;128 | 2.46487 | řezová metoda
vozovka_chodník-obrusná vrstva | 12.9037 | 1 | no | ((-642668.99531443,-1062722.188246,232.195303788576),(-642666.506124775,-1062718.93631235,232.315820170458)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.08978 | 0.09187 | obrusná vrstva | vozovka/chodník | 574A03 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | ACO 11 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.249868 | řezová metoda | 0.04
vozovka_chodník-obrusná vrstva | 13.4232 | 1 | no | ((-642668.574695901,-1062725.27210403,232.19228159325),(-642666.069058118,-1062721.89450357,232.315820170458)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.08978 | 0.09187 | obrusná vrstva | vozovka/chodník | 574A03 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | ACO 11 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.26006 | řezová metoda | 0.04
vozovka_chodník-podkladní asfaltová vrstva | 13.2084 | 1 | no | ((-642668.99531443,-1062722.188246,232.125303788575),(-642666.506124775,-1062718.93631235,232.275820170458)) | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.08978 | 0.09187 | podkladní asfaltová vrstva | vozovka/chodník | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.437268 | řezová metoda | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 13.7353 | 1 | no | ((-642668.574695901,-1062725.27210403,232.12228159325),(-642666.069058118,-1062721.89450357,232.275820170458)) | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.08978 | 0.09187 | podkladní asfaltová vrstva | vozovka/chodník | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.455105 | řezová metoda | 0.07
vozovka_chodník-horní podkladní vrstva | 14.0211 | 1 | no | ((-642668.99531443,-1062722.188246,231.975303788576),(-642666.506124775,-1062718.93631235,232.205820170458)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.08978 | 0.09187 | horní podkladní vrstva | vozovka/chodník | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 0.937004 | řezová metoda | 0.15
vozovka_chodník-horní podkladní vrstva | 14.5674 | 1 | no | ((-642668.574695901,-1062725.27210403,231.97228159325),(-642666.069058118,-1062721.89450357,232.205820170458)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.08978 | 0.09187 | horní podkladní vrstva | vozovka/chodník | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 0.975225 | řezová metoda | 0.15
vozovka_chodník-spodní podkladní vrstva | 14.6058 | 1 | no | ((-642668.99531443,-1062722.188246,231.760364448946),(-642666.506124775,-1062718.93631235,232.055820170458)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.08978 | 0.09187 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 1.29603 | řezová metoda | 0.2
vozovka_chodník-spodní podkladní vrstva | 15.1694 | 1 | no | ((-642668.574695901,-1062725.27210403,231.756737814556),(-642666.069058118,-1062721.89450357,232.055820170458)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.08978 | 0.09187 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 1.35088 | řezová metoda | 0.2
vozovka_chodník-podkladní asfaltová vrstva | 0.691887 | 1 | no | ((-642668.13678011,-1062725.37675042,232.119639188187),(-642666.054198062,-1062724.9723819,232.19795028463)) | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.08978 | 0.09187 | podkladní asfaltová vrstva | vozovka/chodník | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0128665 | řezová metoda | 0.07
vozovka_chodník-zpevnění krajnic | 5.15407 | 1 | no | ((-642668.13678011,-1062726.36938,231.993139647503),(-642665.913242101,-1062724.9723819,232.23795028463)) | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.08978 | 0.09187 | zpevnění krajnic | vozovka/chodník | 56960 | I1+S1+E1+Z1+M3+F1 | nerelevantni | D.1.3.4 | Recyklovaný materiál | VL 1 | P2 | 128;128;128 | 0.253805 | řezová metoda
2 x zemní práce-zemní krajnice a dosypávky | 3.26976 | 1 | no | ((-642668.095448981,-1062726.26807284,231.876628414549),(-642665.927637013,-1062725.26344089,232.063952736838)) | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.08978 | 0.09187 | zemní krajnice a dosypávky | zemní práce | 173103 | I1+S1+E1+Z1+M3+F1 | nerelevantni | D.1.3.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 0.116826 | řezová metoda
záchytné systémy-svodidlo | 42.8899 | 1 | no | ((-642737.739967144,-1062728.17727214,232.097253787937),(-642691.17074103,-1062721.75086257,233.798781610444)) | 4 | záchytné systémy-svodidlo | Barva_4 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.02047 | 0.06746 | svodidlo | záchytné systémy | 9113A1 | I1+S2+E1+Z1+M1+F1 |  |  |  |  | P2 | 0;255;255 | CZ_S2 - Reference: D.1.3.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: svodidlo; Stavební výrobek: svodidlo min. N2; Specifikace: jednostranné ocelové; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 46.99
záchytné systémy-svodidlo | 105.855 | 1 | no | ((-642667.00676509,-1062718.45867945,231.406987293545),(-642552.087081151,-1062702.5135978,232.957)) | 4 | záchytné systémy-svodidlo | Barva_4 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.09187 | 0.207 | svodidlo | záchytné systémy | 9113A1 | I1+S2+E1+Z1+M1+F1 |  |  |  |  | P2 | 0;255;255 | CZ_S2 - Reference: D.1.3.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: svodidlo; Stavební výrobek: svodidlo min. N2; Specifikace: jednostranné ocelové; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 116
vozovka_chodník-obrusná vrstva | 5.17644 | 1 | no | ((-642736.684010934,-1062735.63191296,232.28828886343),(-642688.214975836,-1062728.18290792,233.031247768159)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.02046 | 0.06949 | obrusná vrstva | vozovka/chodník | 574A03 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | ACO 11 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.01986 | řezová metoda | 0.04
vozovka_chodník-horní podkladní vrstva | 52.8744 | 1 | no | ((-642736.684010934,-1062736.04695847,232.057808631637),(-642688.156038302,-1062728.18290792,232.921247768159)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.02046 | 0.06949 | horní podkladní vrstva | vozovka/chodník | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 2.37237 | řezová metoda | 0.15
vozovka_chodník-spodní podkladní vrstva | 144.202 | 1 | no | ((-642736.684010934,-1062736.930269,231.813151629771),(-642688.031415382,-1062728.18290792,232.771247768159)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.02046 | 0.06949 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 10.5716 | řezová metoda | 0.2
vozovka_chodník-obrusná vrstva | 2.14246 | 1 | no | ((-642688.217823272,-1062728.20295992,232.197443955516),(-642668.133932674,-1062725.27210403,232.328795192544)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.06949 | 0.08978 | obrusná vrstva | vozovka/chodník | 574A03 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | ACO 11 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00821907 | řezová metoda | 0.04
vozovka_chodník-spodní podkladní vrstva | 59.8243 | 1 | no | ((-642688.217823272,-1062729.4956157,231.722618719454),(-642667.950459949,-1062725.27210403,232.068795192544)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.06949 | 0.08978 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 4.35807 | řezová metoda | 0.2
zemní práce-zemní krajnice a dosypávky | 30.7968 | 1 | no | ((-642688.176492143,-1062729.17949452,231.882264979901),(-642667.995349971,-1062725.56316303,232.154797644768)) | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.06949 | 0.08978 | zemní krajnice a dosypávky | zemní práce | 173103 | I1+S1+E1+Z1+M3+F1 | nerelevantni | D.1.3.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 1.13575 | řezová metoda
vozovka_chodník-obrusná vrstva | 0.221333 | 1 | no | ((-642668.13678011,-1062725.29215604,232.191775264136),(-642666.066210682,-1062724.9723819,232.23795028463)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.08978 | 0.09187 | obrusná vrstva | vozovka/chodník | 574A03 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | ACO 11 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.000846308 | řezová metoda | 0.04
vozovka_chodník-horní podkladní vrstva | 2.34555 | 1 | no | ((-642668.13678011,-1062725.70720155,231.961295032342),(-642666.007273149,-1062724.9723819,232.12795028463)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.08978 | 0.09187 | horní podkladní vrstva | vozovka/chodník | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 0.101096 | řezová metoda | 0.15
vozovka_chodník-spodní podkladní vrstva | 6.54312 | 1 | no | ((-642668.13678011,-1062726.58419402,231.716982154104),(-642665.88274699,-1062724.9723819,231.97795028463)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.08978 | 0.09187 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 0.448419 | řezová metoda | 0.2
zemní práce-rozprostření ornice (ohumusovani) | 222.783 | 1 | no | ((-642736.584333061,-1062737.87948684,231.310880648381),(-642687.776443782,-1062728.88485202,232.82404965063)) | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0 | 0.695 | rozprostření ornice (ohumusovani) | zemní práce | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | ornice | nerelevantni | P100 | 165;207;99 | 0.697191 | řezová metoda | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 93.6677 | 1 | no | ((-642688.118145399,-1062731.29115775,231.204178995716),(-642667.758905424,-1062725.97404814,232.121597075023)) | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.06949 | 0.08978 | rozprostření ornice (ohumusovani) | zemní práce | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | ornice | nerelevantni | P100 | 165;207;99 | 1.73932 | řezová metoda | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 11.1577 | 1 | no | ((-642668.037102237,-1062728.05797088,231.200000349468),(-642665.630896527,-1062725.674326,232.0307521671)) | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.08978 | 0.09187 | rozprostření ornice (ohumusovani) | zemní práce | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | ornice | nerelevantni | P100 | 165;207;99 | 0.697191 | řezová metoda | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 207.831 | 1 | no | ((-642738.189031657,-1062727.22902347,231.54),(-642689.296655066,-1062718.29859548,232.774583492923)) | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.02046 | 0.06949 | rozprostření ornice (ohumusovani) | zemní práce | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | ornice | nerelevantni | P100 | 165;207;99 | 13.4071 | řezová metoda | 0.15
vozovka_chodník-obrusná vrstva | 5.17607 | 1 | no | ((-642737.672120919,-1062728.67351827,232.291885116701),(-642689.089923674,-1062722.02141529,233.041781610444)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.02046 | 0.06949 | obrusná vrstva | vozovka/chodník | 574A03 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | ACO 11 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.01986 | řezová metoda | 0.04
vozovka_chodník-podkladní asfaltová vrstva | 15.9608 | 1 | no | ((-642737.68413354,-1062728.67351827,232.219749040751),(-642689.089923674,-1062721.93682091,233.001781610444)) | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.02046 | 0.06949 | podkladní asfaltová vrstva | vozovka/chodník | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.301933 | řezová metoda | 0.07
vozovka_chodník-horní podkladní vrstva | 52.873 | 1 | no | ((-642737.731058452,-1062728.67351827,232.061404884907),(-642689.089923674,-1062721.60636978,232.931781610444)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.02046 | 0.06949 | horní podkladní vrstva | vozovka/chodník | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 2.37237 | řezová metoda | 0.15
vozovka_chodník-spodní podkladní vrstva | 211.29 | 1 | no | ((-642737.950087277,-1062728.67351827,231.787590057028),(-642689.089923674,-1062719.74274866,232.781781610444)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.02046 | 0.06949 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 15.5264 | řezová metoda | 0.2
vozovka_chodník-zpevnění krajnic | 190.602 | 1 | no | ((-642737.930533613,-1062728.67351827,232.012776134842),(-642689.089923674,-1062719.94826544,233.041781610444)) | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.02046 | 0.06949 | zpevnění krajnic | vozovka/chodník | 56960 | I1+S1+E1+Z1+M3+F1 | nerelevantni | D.1.3.4 | Recyklovaný materiál | VL 1 | P2 | 128;128;128 | 11.5305 | řezová metoda
zemní práce-zemní krajnice a dosypávky | 140.36 | 1 | no | ((-642737.905197255,-1062728.38245927,231.952918641996),(-642689.131254802,-1062720.24639935,232.867784062668)) | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.02046 | 0.06949 | zemní krajnice a dosypávky | zemní práce | 173103 | I1+S1+E1+Z1+M3+F1 | nerelevantni | D.1.3.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 6.7235 | řezová metoda
zemní práce-rozprostření ornice (ohumusovani) | 9.69461 | 1 | no | ((-642669.446294684,-1062717.77904239,231.316198505435),(-642667.131317541,-1062715.50316143,231.973816679312)) | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.0898 | 0.09187 | rozprostření ornice (ohumusovani) | zemní práce | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | ornice | nerelevantni | P100 | 165;207;99 | 0.593888 | řezová metoda | 0.15
vozovka_chodník-obrusná vrstva | 0.219309 | 1 | no | ((-642668.979173613,-1062719.22353719,232.194797459462),(-642666.926195555,-1062718.91626035,232.240973558492)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.0898 | 0.09187 | obrusná vrstva | vozovka/chodník | 574A03 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | ACO 11 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.000838542 | řezová metoda | 0.04
vozovka_chodník-podkladní asfaltová vrstva | 0.68565 | 1 | no | ((-642668.991186233,-1062719.22353719,232.122661383512),(-642666.926195555,-1062718.83166597,232.200973558492)) | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.0898 | 0.09187 | podkladní asfaltová vrstva | vozovka/chodník | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0127485 | řezová metoda | 0.07
vozovka_chodník-horní podkladní vrstva | 2.32491 | 1 | no | ((-642669.038111146,-1062719.22353719,231.964317227668),(-642666.926195555,-1062718.50121483,232.130973558492)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.0898 | 0.09187 | horní podkladní vrstva | vozovka/chodník | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 0.100168 | řezová metoda | 0.15
vozovka_chodník-spodní podkladní vrstva | 9.42169 | 1 | no | ((-642669.256688926,-1062719.22353719,231.700540986733),(-642666.926195555,-1062716.9620033,231.980973558492)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.0898 | 0.09187 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.3.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 0.649375 | řezová metoda | 0.2
vozovka_chodník-zpevnění krajnic | 8.42541 | 1 | no | ((-642669.237586307,-1062719.22353719,231.936161842836),(-642666.926195555,-1062717.09648569,232.240973558492)) | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.0898 | 0.09187 | zpevnění krajnic | vozovka/chodník | 56960 | I1+S1+E1+Z1+M3+F1 | nerelevantni | D.1.3.4 | Recyklovaný materiál | VL 1 | P2 | 128;128;128 | 0.484154 | řezová metoda
zemní práce-zemní krajnice a dosypávky | 6.14161 | 1 | no | ((-642669.211798903,-1062718.93247819,231.860187247177),(-642666.967526684,-1062717.27812448,232.066976010724)) | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.0898 | 0.09187 | zemní krajnice a dosypávky | zemní práce | 173103 | I1+S1+E1+Z1+M3+F1 | nerelevantni | D.1.3.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 0.28164 | řezová metoda
dopravní značení-směrový sloupek | 0.0854513 | 5 | yes | ((-642737.74966477,-1062728.21471353,233.801308685978),(-642737.669664769,-1062728.13471353,234.101308685978)) | 7 | dopravní značení-směrový sloupek | Barva_7 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 20.53 | 20.53 | směrový sloupek | dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 |  |  |  |  | P10 | 255;255;255 | CZ_S2 - Reference: D.1.3.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11 a,b; Podrobná specifikace: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-směrový sloupek | 0.211115 | 2 | yes | ((-642736.530836112,-1062736.12783321,232.989222688629),(-642736.450836112,-1062736.04783321,233.789222688629)) | 7 | dopravní značení-směrový sloupek | Barva_7 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 20.62 | 20.62 | směrový sloupek | dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 |  |  |  |  | P10 | 255;255;255 | CZ_S2 - Reference: D.1.3.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11 a,b; Podrobná specifikace: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-směrový sloupek | 0.0854513 | 5 | yes | ((-642698.112312812,-1062722.83502355,233.185386568588),(-642698.032312812,-1062722.75502355,233.485386568588)) | 7 | dopravní značení-směrový sloupek | Barva_7 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 60.53 | 60.53 | směrový sloupek | dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 |  |  |  |  | P10 | 255;255;255 | CZ_S2 - Reference: D.1.3.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11 a,b; Podrobná specifikace: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-směrový sloupek | 0.211115 | 2 | yes | ((-642697.093603195,-1062730.00890468,232.381559387534),(-642697.013603195,-1062729.92890468,233.181559387534)) | 7 | dopravní značení-směrový sloupek | Barva_7 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 60.53 | 60.53 | směrový sloupek | dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 |  |  |  |  | P10 | 255;255;255 | CZ_S2 - Reference: D.1.3.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11 a,b; Podrobná specifikace: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-směrový sloupek | 0.0854513 | 5 | yes | ((-642658.490810813,-1062717.34371616,232.99),(-642658.410810813,-1062717.26371616,233.29)) | 7 | dopravní značení-směrový sloupek | Barva_7 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.08 | 0.08 | směrový sloupek | dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 |  |  |  |  | P10 | 255;255;255 | CZ_S2 - Reference: D.1.3.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11 a,b; Podrobná specifikace: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-směrový sloupek | 0.211115 | 2 | yes | ((-642657.507155934,-1062724.27073742,232.19),(-642657.427155934,-1062724.19073742,232.99)) | 7 | dopravní značení-směrový sloupek | Barva_7 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.08 | 0.08 | směrový sloupek | dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 |  |  |  |  | P10 | 255;255;255 | CZ_S2 - Reference: D.1.3.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11 a,b; Podrobná specifikace: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-směrový sloupek | 0.0854513 | 5 | yes | ((-642608.950069715,-1062710.57721113,232.74),(-642608.870069715,-1062710.49721113,233.04)) | 7 | dopravní značení-směrový sloupek | Barva_7 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.13 | 0.13 | směrový sloupek | dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 |  |  |  |  | P10 | 255;255;255 | CZ_S2 - Reference: D.1.3.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11 a,b; Podrobná specifikace: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-směrový sloupek | 0.211115 | 2 | yes | ((-642608.065201288,-1062716.80856579,231.94),(-642607.985201288,-1062716.72856579,232.74)) | 7 | dopravní značení-směrový sloupek | Barva_7 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.13 | 0.13 | směrový sloupek | dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 |  |  |  |  | P10 | 255;255;255 | CZ_S2 - Reference: D.1.3.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11 a,b; Podrobná specifikace: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-směrový sloupek | 0.0854513 | 5 | yes | ((-642559.436161724,-1062703.62174399,232.5),(-642559.356161724,-1062703.54174399,232.8)) | 7 | dopravní značení-směrový sloupek | Barva_7 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.18 | 0.18 | směrový sloupek | dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 |  |  |  |  | P10 | 255;255;255 | CZ_S2 - Reference: D.1.3.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11 a,b; Podrobná specifikace: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-směrový sloupek | 0.211115 | 2 | yes | ((-642558.572349561,-1062709.70481779,231.7),(-642558.492349561,-1062709.62481779,232.5)) | 7 | dopravní značení-směrový sloupek | Barva_7 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.18 | 0.18 | směrový sloupek | dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 |  |  |  |  | P10 | 255;255;255 | CZ_S2 - Reference: D.1.3.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11 a,b; Podrobná specifikace: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-směrový sloupek | 0.211115 | 2 | yes | ((-642689.657289102,-1062721.19439408,232.259743760543),(-642689.577289102,-1062721.11439408,233.059743760543)) | 7 | dopravní značení-směrový sloupek | Barva_7 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 69.13 | 69.13 | směrový sloupek | dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 |  |  |  |  | P10 | 255;255;255 | CZ_S2 - Reference: D.1.3.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11 g; Podrobná specifikace: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-směrový sloupek | 0.211115 | 2 | yes | ((-642668.933893148,-1062718.42668867,232.17504229747),(-642668.853893148,-1062718.34668867,232.97504229747)) | 7 | dopravní značení-směrový sloupek | Barva_7 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 90.04 | 90.04 | směrový sloupek | dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 |  |  |  |  | P10 | 255;255;255 | CZ_S2 - Reference: D.1.3.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11 g; Podrobná specifikace: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
zemní práce-sanace | 321.025 | 2 | yes | ((-642736.878049899,-1062737.62058467,231.374553640414),(-642686.976155606,-1062727.08098067,232.581747876327)) | 40 | zemní práce-sanace | Barva_40 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 20.4 | 70.46 | sanace | zemní práce | 17180 | I1+S1+E1+Z1+M3+F1 | nerelevantni | D.1.3.4 | sypanina | ČSN 73 6133 | P100 | 255;165;0 | 56.2846 | řezová metoda
dopravní značení-svislé dopravní značení | 0.587153 | 2 | yes | ((-642702.987386455,-1062721.91107459,232.075538938242),(-642702.909175045,-1062721.83286318,234.426065058322)) | 7 | dopravní značení-svislé dopravní značení | Barva_7 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 55.83 | 55.83 | svislé dopravní značení | dopravní značení | 914924 | I1+S2+E1+Z1+M4+F1 |  |  |  |  | P10 | 255;255;255 | CZ_S2 - Reference: D.1.3.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: sloupek; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
trasa-průjezdní a průchozí prostor | 0.06 | 2 | yes | ((-642737.206261719,-1062731.93410529,233.13),(-642737.106261719,-1062731.83410529,233.23)) | 9 | trasa-průjezdní a průchozí prostor | Barva_9 |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  | P2 | 191;191;191 | CZ_I3 - Fáze projektu: PDPS; Staničení od: 20.46; Název (trasy): III/322 XX Pod Dubem; Staničení do: 20.57; Označení elementu: průjezdní a průchozí prostor; Označení průjezdného profilu: nerelevantni; Klasifikační systém: nerelevantni; Označení položky: nerelevantni; Označení šablony vlastností: I3+E1+Z1+F1
dopravní značení-svislé dopravní značení | 0.869588 | 8 | yes | ((-642633.161945392,-1062713.16233621,232.07),(-642633.055249682,-1062713.0556405,235.57)) | 7 | dopravní značení-svislé dopravní značení | Barva_7 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.13 | 0.13 | svislé dopravní značení | dopravní značení | 914924 | I1+S2+E1+Z1+M4+F1 |  |  |  |  | P10 | 255;255;255 | CZ_S2 - Reference: D.1.3.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: sloupek; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.9433 | 10 | yes | ((-642633.425835336,-1062711.18031832,231.77),(-642633.319139626,-1062711.07362261,235.57)) | 7 | dopravní značení-svislé dopravní značení | Barva_7 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.13 | 0.13 | svislé dopravní značení | dopravní značení | 914924 | I1+S2+E1+Z1+M4+F1 |  |  |  |  | P10 | 255;255;255 | CZ_S2 - Reference: D.1.3.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: sloupek; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 9.764 | 8 | yes | ((-642634.177617108,-1062713.36122238,234.57),(-642632.186410271,-1062710.86051746,236.47)) | 7 | dopravní značení-svislé dopravní značení | Barva_7 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 0.125 | 0.125 | svislé dopravní značení | dopravní značení | 914521 | I1+S2+E1+Z1+M4+F1 |  |  |  |  | P10 | 255;255;255 | CZ_S2 - Reference: D.1.3.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: IS9b; Specifikace: velikost velkoplošná, RA2; Podrobná specifikace: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.813672 | 9 | yes | ((-642702.941389724,-1062722.17945399,233.916289429077),(-642702.870169777,-1062721.47986941,234.616289429077)) | 7 | dopravní značení-svislé dopravní značení | Barva_7 | SO 103 | nerelevantni | PDPS | Silnice III/322 XX Pod Dubem | OTSKP | 55.79 | 55.79 | svislé dopravní značení | dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 |  |  |  |  | P10 | 255;255;255 | CZ_S2 - Reference: D.1.3.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: B20; Specifikace: velikost základní, RA2; Podrobná specifikace: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu

# IfcDistributionSystem (2)
Properties - IsReferenceObject: no; IsReferenceStale: no; IsReferenceSubObject: no; IsReferenceValid: no; ShowToolTip: yes; ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: no; IsModifiedGraphics: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no; IsUsed: no; ModifiedPipeNetworkSectionLayerName: C3D-POTRUBI-PR; ModifiedPipePlanLayerName: C3D-POTRUBI; ModifiedPipeProfileLayerName: C3D-PROFIL-POTRUBI; ModifiedStructurePlanLayerName: C3D-SO; ModifiedStructureProfileLayerName: C3D-PROFIL-POTRUBI; PartsListName: Dešťová a splašková kanalizace; PipeNameTemplate: Potrubí-<[Další čítač(CP)]>; PipeNetworkSectionLayerName: C3D-POTRUBI-PR; PipePlanLabelStyleName: Průměr & Délka; PipePlanLayerName: C3D-POTRUBI; PipeProfileLayerName: C3D-PROFIL-POTRUBI; ReferenceSurfaceName: _Stávající DTM; StructureNameTemplate: Š<[Další čítač(CP)]>; StructurePlanLayerName: C3D-SO; StructureProfileLayerName: C3D-PROFIL-POTRUBI; DisplayName: Síť; FingerPrint: -1118077474; CloneMeForDragging: yes; Bounds: ((1E+20,1E+20,1E+20),(-1E+20,-1E+20,-1E+20))
Miscellaneous - IsHighlighting: no; NeedsPromoting: no; SupportsBaseCurveCommands: no; SupportsProfileCommands: no; SwappingReferences: no
General - Linetype: ByLayer; LinetypeScale: 1; Visible: yes; ColorIndex: 256; Layer: ms_odvodnění; PlotStyleName: ByLayer
Geometry - Closed: no; IsPeriodic: no; IsPlanar: yes
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
Name | Name
SO106 | SO106
SO107 | SO107

# IfcGeographicElement (9)
In: UnknownName
PredefinedType: TERRAIN
Properties - HasSnapshot: no; IsSnapshotOutOfDate: no; IsVolumeSurface: no; Lock: no; DisplayName: Povrch TIN; IsReferenceObject: no; IsReferenceStale: no; IsReferenceSubObject: no; IsReferenceValid: no; ShowToolTip: yes; CloneMeForDragging: no; ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: no; IsModifiedGraphics: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no
Miscellaneous - IsHighlighting: no; NeedsPromoting: no; SupportsBaseCurveCommands: no; SupportsProfileCommands: no; SwappingReferences: no; TypeIcon: (Ikona)
General - LayerKey: AeccSurfaceTin; Linetype: ByLayer; LinetypeScale: 1; Visible: yes
Geometry - Closed: no; IsPeriodic: no; IsPlanar: yes
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
CZ_I1 - Označení stavebního objektu: SO 103; Označení podobjektu: nerelevantni; Označení části objektu: nerelevantni; Fáze projektu: PDPS; Název stavebního objektu: Silnice III/322 XX Pod Dubem; Klasifikační systém: OTSKP
CZ_E1 - Datum zahájení prací: 01.05.2025; Datum dokončení: 30.06.2027; Doba trvání: 790; Datum uvedení do provozu: 01.07.2027; Stavební postup / etapa výstavby: nerelevantni
CZ_F1 - Fáze: trvalý stav
Name | AutoRebuild = IsUsed | IsOutOfDate | FingerPrint | Name | StyleName | Bounds | ColorIndex | Layer | PlotStyleName | Staničení od | Staničení do | Označení elementu | Skupina elementů | Označení položky | Označení šablony vlastností | Textura / barva | Skupina přesnosti | Description = Properties, Description | Typ stavebního výrobku | Stavební výrobek | Specifikace | Podrobná specifikace | CZ_S2, Reference | Výrobce = Kategorie stavebního výrobku | Délka | Způsob stanovení délky
zemní práce-pláň | yes | no | -534212532 | zemní práce-pláň | plan | ((-642837.950087277,-1062836.930269,231.700540509899),(-642565.882574064,-1062616.96197906,232.664114044926)) | 96 | zemní práce-pláň | Barva_96 | 20.46 | 91.87 | pláň | zemní práce | 18110 | I1+S1+E1+Z1+M2+F1 | 0;128;0 | P10 | CZ_S1 - Materiál: nerelevantni; specifikace: ČSN 73 6133; podrobná specifikace: nerelevantni; Reference: D.1.3.4; CZ_M2 - Plocha: 650.598; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-spojovací postřik | yes | no | 1620589718 | vozovka_chodník-spojovací postřik | postřiky | ((-642837.679150527,-1062835.68141634,232.190524790053),(-642566.059008147,-1062618.86673273,233.084114044926)) | 4 | vozovka_chodník-spojovací postřik | Barva_4 | 20.46 | 91.87 | spojovací postřik | vozovka/chodník | 572213 | I1+S1+E1+Z1+M2+F1 | 0;255;255 | P2 | CZ_S1 - Materiál: kat. em. 0,35 kg/m2; specifikace: ČSN 73 6129; podrobná specifikace: nerelevantni; Reference: D.1.3.4; CZ_M2 - Plocha: 461.138; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-infiltrační postřik | yes | no | 344907964 | vozovka_chodník-infiltrační postřik | postřiky | ((-642837.698192755,-1062835.8155141,232.117138714104),(-642566.039965919,-1062618.73263496,233.014114044926)) | 4 | vozovka_chodník-infiltrační postřik | Barva_4 | 20.46 | 91.29 | infiltrační postřik | vozovka/chodník | 572123 | I1+S1+E1+Z1+M2+F1 | 0;255;255 | P2 | CZ_S1 - Materiál: kat. em 1,0 kg/m2; specifikace: ČSN 73 6129; podrobná specifikace: nerelevantni; Reference: D.1.3.4; CZ_M2 - Plocha: 478.925; Způsob stanovení plochy: 3D plocha TIN povrchu
dopravní značení-vodorovné dopravní značení-V4 | no | yes | 398320360 | dopravní značení-vodorovné dopravní značení-V4 | vdz | ((-642838.189031657,-1062837.87948684,231.37),(-642565.630718558,-1062615.50311608,233.144114044926)) | 7 | dopravní značení-vodorovné dopravní značení | Barva_7 | 20.46 | 91.87 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V4 | barvou | TP 133 | D.1.3.6 | nerelevantni | 71.4 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V1a | no | yes | -76592279 | dopravní značení-vodorovné dopravní značení-V1a | vdz | ((-642838.189031657,-1062837.87948684,231.37),(-642565.630718558,-1062615.50311608,233.144114044926)) | 7 | dopravní značení-vodorovné dopravní značení | Barva_7 | 20.56 | 91.34 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V1a | barvou | TP 133 | D.1.3.6 | nerelevantni | 71.4 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V4 plast | no | yes | -360320845 | dopravní značení-vodorovné dopravní značení-V4 plast | vdz | ((-642838.189031657,-1062837.87948684,231.37),(-642565.630718558,-1062615.50311608,233.144114044926)) | 7 | dopravní značení-vodorovné dopravní značení | Barva_7 | 20.46 | 91.87 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V4 | plast | TP 133 | D.1.3.6 | nerelevantni | 71.4 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V1a plast | no | yes | -4963050 | dopravní značení-vodorovné dopravní značení-V1a plast | vdz | ((-642838.189031657,-1062837.87948684,231.37),(-642565.630718558,-1062615.50311608,233.144114044926)) | 7 | dopravní značení-vodorovné dopravní značení | Barva_7 | 20.56 | 91.34 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V1a | plast | TP 133 | D.1.3.6 | nerelevantni | 71.4 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V4 (1) | no | yes | -2019967513 | dopravní značení-vodorovné dopravní značení-V4 (1) | vdz | ((-642838.189031657,-1062837.87948684,231.37),(-642565.630718558,-1062615.50311608,233.144114044926)) | 7 | dopravní značení-vodorovné dopravní značení | Barva_7 | 20.46 | 91.87 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V4 | barvou | TP 133 | D.1.3.6 | nerelevantni | 71.3 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V4 plast (1) | no | yes | 2112461136 | dopravní značení-vodorovné dopravní značení-V4 plast (1) | vdz | ((-642838.189031657,-1062837.87948684,231.37),(-642565.630718558,-1062615.50311608,233.144114044926)) | 7 | dopravní značení-vodorovné dopravní značení | Barva_7 | 20.46 | 91.87 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V4 | plast | TP 133 | D.1.3.6 | nerelevantni | 71.3 | Délka 3D křivky
