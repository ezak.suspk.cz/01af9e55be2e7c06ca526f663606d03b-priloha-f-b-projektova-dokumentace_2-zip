Properties of the parts of a building model (IFC4X3_ADD2), part 2 of 2

# IfcBuiltElement (146)
Name | Area | NumChanges | RecordHistory = ShowHistory | Bounds | ColorIndex | Layer | PlotStyleName | podrobná specifikace | CZ_S1, Reference | Materiál | specifikace | Objem | Způsob stanovení objemu | Označení stavebního objektu | Označení podobjektu = Označení části objektu | CZ_I1, Fáze projektu | Název stavebního objektu | CZ_I1, Klasifikační systém | CZ_I1, Staničení od | CZ_I1, Staničení do | CZ_I1, Označení elementu | Skupina elementů | CZ_I1, Označení položky | CZ_I1, Označení šablony vlastností | Skupina přesnosti | Textura / barva | Tloušťka
dopravní značení-svislé dopravní značení | 0.121737 | 2 | yes | ((-639441.595155918,-1063430.62966033,230.40750625121),(-639441.545155918,-1063430.57966033,231.15750625121)) | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  |  |  | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 127.04 | 127.04 | svislé dopravní značení | dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | P10 | 255;255;255 | CZ_S2 - Reference: D.1.4.6; Podrobná specifikace: TP 65; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Specifikace: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.121737 | 2 | yes | ((-639448.863428536,-1063433.95487693,230.062841805802),(-639448.813428536,-1063433.90487693,230.812841805802)) | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  |  |  | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 127.01 | 127.01 | svislé dopravní značení | dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | P10 | 255;255;255 | CZ_S2 - Reference: D.1.4.6; Podrobná specifikace: TP 65; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Specifikace: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.121737 | 2 | yes | ((-639442.85888444,-1063452.05964076,230.254348160019),(-639442.80888444,-1063452.00964076,231.004348160019)) | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  |  |  | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 147.02 | 147.02 | svislé dopravní značení | dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | P10 | 255;255;255 | CZ_S2 - Reference: D.1.4.6; Podrobná specifikace: TP 65; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Specifikace: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.121737 | 2 | yes | ((-639435.697876419,-1063450.57668531,230.257906259024),(-639435.647876419,-1063450.52668531,231.007906259024)) | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  |  |  | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 146.98 | 146.98 | svislé dopravní značení | dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | P10 | 255;255;255 | CZ_S2 - Reference: D.1.4.6; Podrobná specifikace: TP 65; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Specifikace: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
vozovka_chodník-zpevnění krajnic | 12.8984 | 1 | no | ((-639442.156280815,-1063430.39516144,229.859680510369),(-639434.328793253,-1063423.17685471,230.45)) | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.4.4 | Recyklovaný materiál | VL 1 | 0.49345 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 123.88 | 126.72 | zpevnění krajnic | vozovka/chodník | 56960 | I1+S1+E1+Z1+M3+F1 | P2 | 128;128;128
vozovka_chodník-zpevnění krajnic | 13.0286 | 1 | no | ((-639447.327184875,-1063422.23909609,229.859680510368),(-639437.294191132,-1063417.96087778,230.400000000001)) | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.4.4 | Recyklovaný materiál | VL 1 | 0.49855 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 116.4 | 119.34 | zpevnění krajnic | vozovka/chodník | 56960 | I1+S1+E1+Z1+M3+F1 | P2 | 128;128;128
vozovka_chodník-spodní podkladní vrstva | 16.8342 | 1 | no | ((-639442.156280815,-1063430.39516144,229.660000000001),(-639434.304081604,-1063423.17685471,230.34)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.4.4 | ŠDB | ČSN 73 6126-1 | 1.07997 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 123.88 | 126.73 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.23
vozovka_chodník-spodní podkladní vrstva | 16.7383 | 1 | no | ((-639447.327184875,-1063422.23909609,229.66),(-639437.294191132,-1063417.9174113,230.290000000001)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.4.4 | ŠDB | ČSN 73 6126-1 | 1.0585 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 116.4 | 119.34 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.23
vozovka_chodník-obrusná vrstva | 1.77863 | 1 | no | ((-639442.156280815,-1063430.39516144,229.940000000001),(-639434.561082753,-1063423.17685471,230.45)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.4.2 | ACO 16 50/70 | ČSN EN 13 108-1 | 0.010165 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 123.88 | 126.7 | obrusná vrstva | vozovka/chodník | 574A05 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.06
vozovka_chodník-horní podkladní vrstva | 3.28249 | 1 | no | ((-639442.156280815,-1063430.39516144,229.89),(-639434.52401528,-1063423.17685471,230.39)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.4.2 | Recyklovaný materiál | TP 210 | 0.0519927 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 123.88 | 126.71 | horní podkladní vrstva | vozovka/chodník | 56360 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.05
vozovka_chodník-obrusná vrstva | 1.79745 | 1 | no | ((-639447.327184875,-1063422.23909609,229.94),(-639437.294191132,-1063418.36946264,230.400000000001)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.4.2 | ACO 16 50/70 | ČSN EN 13 108-1 | 0.0102756 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 116.4 | 119.34 | obrusná vrstva | vozovka/chodník | 574A05 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.06
vozovka_chodník-horní podkladní vrstva | 3.3171 | 1 | no | ((-639447.327184875,-1063422.23909609,229.89),(-639437.294191132,-1063418.30426292,230.340000000001)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.4.2 | Recyklovaný materiál | TP 210 | 0.0525545 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 116.4 | 119.34 | horní podkladní vrstva | vozovka/chodník | 56360 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.05
dopravní značení-svislé dopravní značení | 1.15108 | 2 | no | ((-639446.413246787,-1063445.0542659,231.87008298724),(-639444.722658366,-1063444.55401065,232.200332806911)) | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  |  |  | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 139.02 | 139.05 | svislé dopravní značení | dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | P10 | 255;255;255 | CZ_S2 - Reference: D.1.4.6; Podrobná specifikace: TP 65; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Specifikace: velikost základní, RA2; Typ stavebního výrobku: SDZ; Stavební výrobek: IS3c; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 1.70914 | 2 | no | ((-639446.171422933,-1063444.99299441,232.200049992418),(-639444.480179926,-1063444.49042607,232.700282814447)) | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  |  |  | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 139.02 | 139.05 | svislé dopravní značení | dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | P10 | 255;255;255 | CZ_S2 - Reference: D.1.4.6; Podrobná specifikace: TP 65; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Specifikace: velikost základní, RA2; Typ stavebního výrobku: SDZ; Stavební výrobek: IS1c; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.52 | 2 | no | ((-639473.371440015,-1063407.25968399,231.762514859089),(-639472.978114205,-1063406.6610944,232.469692347455)) | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  |  |  | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 87.82 | 87.84 | svislé dopravní značení | dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | P10 | 255;255;255 | CZ_S2 - Reference: D.1.4.6; Podrobná specifikace: TP 65; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Specifikace: velikost základní, RA2; Typ stavebního výrobku: SDZ; Stavební výrobek: P3; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 1.15108 | 2 | no | ((-639446.414517452,-1063445.0497758,231.540115982294),(-639444.723929032,-1063444.54952054,231.870365801966)) | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  |  |  | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 139.01 | 139.04 | svislé dopravní značení | dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | P10 | 255;255;255 | CZ_S2 - Reference: D.1.4.6; Podrobná specifikace: TP 65; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Specifikace: velikost základní, RA2; Typ stavebního výrobku: SDZ; Stavební výrobek: IS3c; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.476894 | 2 | yes | ((-639542.009363216,-1063371.56389673,229.449765792042),(-639541.949363216,-1063371.50389673,231.949765792042)) | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  |  |  | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 10.1 | 10.1 | svislé dopravní značení | dopravní značení | 914924 | I1+S2+E1+Z1+M4+F1 | P10 | 255;255;255 | CZ_S2 - Reference: D.1.4.6; Podrobná specifikace: TP 65; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Specifikace: velikost základní, RA2; Typ stavebního výrobku: SDZ; Stavební výrobek: sloupek; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.476894 | 2 | yes | ((-639506.342262592,-1063389.51939015,229.645305003413),(-639506.282262592,-1063389.45939015,232.145305003413)) | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  |  |  | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 50.03 | 50.03 | svislé dopravní značení | dopravní značení | 914924 | I1+S2+E1+Z1+M4+F1 | P10 | 255;255;255 | CZ_S2 - Reference: D.1.4.6; Podrobná specifikace: TP 65; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Specifikace: velikost základní, RA2; Typ stavebního výrobku: SDZ; Stavební výrobek: sloupek; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.476894 | 2 | yes | ((-639473.171224528,-1063407.01216405,229.769550940174),(-639473.111224528,-1063406.95216405,232.269550940174)) | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  |  |  | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 87.9 | 87.9 | svislé dopravní značení | dopravní značení | 914924 | I1+S2+E1+Z1+M4+F1 | P10 | 255;255;255 | CZ_S2 - Reference: D.1.4.6; Podrobná specifikace: TP 65; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Specifikace: velikost základní, RA2; Typ stavebního výrobku: SDZ; Stavební výrobek: sloupek; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.476894 | 2 | yes | ((-639445.464223721,-1063444.84763673,230),(-639445.404223721,-1063444.78763673,232.5)) | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  |  |  | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 139.09 | 139.09 | svislé dopravní značení | dopravní značení | 914924 | I1+S2+E1+Z1+M4+F1 | P10 | 255;255;255 | CZ_S2 - Reference: D.1.4.6; Podrobná specifikace: TP 65; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Specifikace: velikost základní, RA2; Typ stavebního výrobku: SDZ; Stavební výrobek: sloupek; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.835664 | 2 | yes | ((-639542.190988889,-1063371.83260488,231.249765792042),(-639541.848032765,-1063371.19453545,231.949765792042)) | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  |  |  | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 10.01 | 10.04 | svislé dopravní značení | dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | P10 | 255;255;255 | CZ_S2 - Reference: D.1.4.6; Podrobná specifikace: TP 65; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Specifikace: velikost základní, RA2; Typ stavebního výrobku: SDZ; Stavební výrobek: B20; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.835664 | 2 | yes | ((-639506.521030031,-1063389.78992949,231.445305003413),(-639506.184192347,-1063389.14900156,232.145305003413)) | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  |  |  | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 49.94 | 49.97 | svislé dopravní značení | dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | P10 | 255;255;255 | CZ_S2 - Reference: D.1.4.6; Podrobná specifikace: TP 65; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Specifikace: velikost základní, RA2; Typ stavebního výrobku: SDZ; Stavební výrobek: B20; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
zemní práce-násyp | 1273.9 | 1 | no | ((-639477.089577077,-1063461.10532249,228.930856560931),(-639432.79334336,-1063404.63388294,230.04478777071)) | 3 | zemní práce-násyp | Barva_3 | nerelevantni | D.1.4.4 | vhodný nebo podmínečně vhodný do násypu | ČSN 73 6133 | 325.842 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 83.98 | 156.2 | násyp | zemní práce | 17180 | I1+S1+E1+Z1+M3+F1 | P100 | 0;255;0
vozovka_chodník-zpevnění krajnic | 58.4009 | 1 | no | ((-639551.03350143,-1063378.24120828,229.346739043389),(-639528.430075822,-1063366.13800826,229.706830892373)) | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.4.4 | Recyklovaný materiál | VL 1 | 3.00556 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0 | 24.74 | zpevnění krajnic | vozovka/chodník | 56960 | I1+S1+E1+Z1+M3+F1 | P2 | 128;128;128
vozovka_chodník-zpevnění krajnic | 11.5285 | 1 | no | ((-639525.950215029,-1063381.89461311,229.483981049683),(-639521.162838745,-1063378.74794497,229.74659323375)) | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.4.4 | Recyklovaný materiál | VL 1 | 0.583228 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 28.07 | 32.88 | zpevnění krajnic | vozovka/chodník | 56960 | I1+S1+E1+Z1+M3+F1 | P2 | 128;128;128
vozovka_chodník-zpevnění krajnic | 8.46303 | 1 | no | ((-639518.823202843,-1063384.89177321,229.522976157248),(-639515.200982883,-1063382.33085556,229.779213244005)) | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.4.4 | Recyklovaný materiál | VL 1 | 0.424809 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 36.05 | 39.55 | zpevnění krajnic | vozovka/chodník | 56960 | I1+S1+E1+Z1+M3+F1 | P2 | 128;128;128
vozovka_chodník-zpevnění krajnic | 7.96513 | 1 | no | ((-639528.892061377,-1063379.73478962,229.467884877576),(-639525.459091171,-1063377.26901212,229.72308649332)) | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.4.4 | Recyklovaný materiál | VL 1 | 0.399077 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 24.78 | 28.07 | zpevnění krajnic | vozovka/chodník | 56960 | I1+S1+E1+Z1+M3+F1 | P2 | 128;128;128
vozovka_chodník-zpevnění krajnic | 7.49072 | 1 | no | ((-639521.624080746,-1063383.29791625,229.507651287298),(-639518.37143261,-1063380.92279074,229.7618662794)) | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.4.4 | Recyklovaný materiál | VL 1 | 0.37456 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 32.92 | 36 | zpevnění krajnic | vozovka/chodník | 56960 | I1+S1+E1+Z1+M3+F1 | P2 | 128;128;128
vozovka_chodník-zpevnění krajnic | 265.451 | 1 | no | ((-639515.657711993,-1063460.95906695,229.540295989581),(-639440.664081778,-1063383.92221957,230.343211609592)) | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.4.4 | Recyklovaný materiál | VL 1 | 13.7393 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 39.59 | 156.2 | zpevnění krajnic | vozovka/chodník | 56960 | I1+S1+E1+Z1+M3+F1 | P2 | 128;128;128
vozovka_chodník-zpevnění krajnic | 25.2284 | 1 | no | ((-639548.06533391,-1063365.99832461,229.346739043389),(-639538.070647284,-1063360.23382351,229.637842777853)) | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.4.4 | Recyklovaný materiál | VL 1 | 1.29123 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0 | 10.63 | zpevnění krajnic | vozovka/chodník | 56960 | I1+S1+E1+Z1+M3+F1 | P2 | 128;128;128
vozovka_chodník-zpevnění krajnic | 27.4493 | 1 | no | ((-639515.010997108,-1063382.5308158,229.523052828634),(-639505.146576729,-1063376.80026843,229.817776453434)) | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.4.4 | Recyklovaný materiál | VL 1 | 1.37064 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 37 | 47.44 | zpevnění krajnic | vozovka/chodník | 56960 | I1+S1+E1+Z1+M3+F1 | P2 | 128;128;128
vozovka_chodník-zpevnění krajnic | 10.9341 | 1 | no | ((-639488.562652125,-1063393.13295038,229.672305131402),(-639483.977191425,-1063390.14717056,229.947519538473)) | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.4.4 | Recyklovaný materiál | VL 1 | 0.552264 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 66.6 | 71.14 | zpevnění krajnic | vozovka/chodník | 56960 | I1+S1+E1+Z1+M3+F1 | P2 | 128;128;128
vozovka_chodník-zpevnění krajnic | 62.3021 | 1 | no | ((-639538.562986207,-1063377.83872822,229.398730686038),(-639514.492674818,-1063365.01086912,229.76670946329)) | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.4.4 | Recyklovaný materiál | VL 1 | 3.20561 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 10.64 | 36.99 | zpevnění krajnic | vozovka/chodník | 56960 | I1+S1+E1+Z1+M3+F1 | P2 | 128;128;128
vozovka_chodník-zpevnění krajnic | 45.4538 | 1 | no | ((-639505.676722992,-1063391.13389187,229.571890379321),(-639488.071773615,-1063381.46786457,229.911409232623)) | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.4.4 | Recyklovaný materiál | VL 1 | 2.33359 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 47.44 | 66.59 | zpevnění krajnic | vozovka/chodník | 56960 | I1+S1+E1+Z1+M3+F1 | P2 | 128;128;128
vozovka_chodník-zpevnění krajnic | 209.15 | 1 | no | ((-639484.470905324,-1063459.93172064,229.708459284116),(-639433.63042985,-1063392.14586967,230.449579143284)) | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.4.4 | Recyklovaný materiál | VL 1 | 10.6279 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 71.15 | 156.2 | zpevnění krajnic | vozovka/chodník | 56960 | I1+S1+E1+Z1+M3+F1 | P2 | 128;128;128
trasa-průjezdní a průchozí prostor | 0.06 | 2 | yes | ((-639549.300520052,-1063363.68101514,229.65),(-639549.200520051,-1063363.58101514,229.75)) | 9 | trasa-průjezdní a průchozí prostor | Barva_9 |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  | P2 | 191;191;191 | CZ_I3 - Fáze projektu: PDPS; Staničení od: 0; Název (trasy): III/322 XX Zminný; Staničení do: 0.09; Označení elementu: průjezdní a průchozí prostor; Označení průjezdného profilu: nerelevantni; Klasifikační systém: nerelevantni; Označení položky: nerelevantni; Označení šablony vlastností: I3+E1+Z1+F1

# IfcGeographicElement (8)
In: UnknownName
PredefinedType: TERRAIN
Properties - HasSnapshot: no; IsOutOfDate: no; IsSnapshotOutOfDate: no; IsVolumeSurface: no; Lock: no; DisplayName: Povrch TIN; IsReferenceObject: no; IsReferenceStale: no; IsReferenceSubObject: no; IsReferenceValid: no; ShowToolTip: yes; CloneMeForDragging: no; ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: no; IsModifiedGraphics: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no
Miscellaneous - IsHighlighting: no; NeedsPromoting: no; SupportsBaseCurveCommands: no; SupportsProfileCommands: no; SwappingReferences: no; TypeIcon: (Ikona)
General - LayerKey: AeccSurfaceTin; Linetype: ByLayer; LinetypeScale: 1; Visible: yes
Geometry - Closed: no; IsPeriodic: no; IsPlanar: yes
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
CZ_F1 - Fáze: trvalý stav
CZ_I1 - Označení stavebního objektu: SO 104; Označení podobjektu: nerelevantni; Označení části objektu: nerelevantni; Fáze projektu: PDPS; Název stavebního objektu: Silnice III/322 XX Zminný; Klasifikační systém: OTSKP
CZ_E1 - Datum zahájení prací: 01.05.2025; Datum dokončení: 30.06.2027; Doba trvání: 790; Datum uvedení do provozu: 01.07.2027; Stavební postup / etapa výstavby: nerelevantni
Name | AutoRebuild | FingerPrint | IsUsed | Name | StyleName | Bounds | ColorIndex | Layer | PlotStyleName | Textura / barva | Skupina přesnosti | Staničení od | Staničení do | Označení elementu | Skupina elementů | Označení položky | Označení šablony vlastností
zemní práce-pláň | yes | -323612227 | yes | zemní práce-pláň | plan | ((-639651.129211845,-1063560.99024856,229.072489825222),(-639333.416947236,-1063260.04343939,230.04478777071)) | 96 | zemní práce-pláň | Barva_96 | 0;128;0 | P100 | 10.62 | 153.26 | pláň | zemní práce | 18110 | I1+S1+E1+Z1+M2+F1 | CZ_S1 - Materiál: nerelevantni; specifikace: ČSN 73 6133; podrobná specifikace: nerelevantni; Reference: D.1.4.4; CZ_M2 - Plocha: 1356.26; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-spojovací postřik | yes | -1346401580 | yes | vozovka_chodník-spojovací postřik | postřiky | ((-639650.544803076,-1063560.80181601,229.545374660046),(-639334.707037022,-1063261.20592679,230.41055475304)) | 4 | vozovka_chodník-spojovací postřik | Barva_4 | 0;255;255 | P2 | 10.62 | 153.26 | spojovací postřik | vozovka/chodník | 572213 | I1+S1+E1+Z1+M2+F1 | CZ_S1 - Materiál: kat. em. 0,35 kg/m2; specifikace: ČSN 73 6129; podrobná specifikace: nerelevantni; Reference: D.1.4.4; CZ_M2 - Plocha: 959.505; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-infiltrační postřik | yes | 875749397 | yes | vozovka_chodník-infiltrační postřik | postřiky | ((-639650.583180551,-1063560.81416492,229.473238584097),(-639334.622491076,-1063261.12958753,230.344762070113)) | 4 | vozovka_chodník-infiltrační postřik | Barva_4 | 0;255;255 | P2 | 10.62 | 153.26 | infiltrační postřik | vozovka/chodník | 572123 | I1+S1+E1+Z1+M2+F1 | CZ_S1 - Materiál: kat. em 1,0 kg/m2; specifikace: ČSN 73 6129; podrobná specifikace: nerelevantni; Reference: D.1.4.4; CZ_M2 - Plocha: 986.153; Způsob stanovení plochy: 3D plocha TIN povrchu
zemní práce-pláň 2 | yes | 846768287 | no | zemní práce-pláň 2 | plan | ((-639547.535389179,-1063530.50341949,229.66),(-639334.575909743,-1063318.39554252,230.11)) | 96 | zemní práce-pláň | Barva_96 | 0;128;0 | P100 | 116.4 | 126.7 | pláň | zemní práce | 18110 | I1+S1+E1+Z1+M2+F1 | CZ_S1 - Materiál: nerelevantni; specifikace: ČSN 73 6133; podrobná specifikace: nerelevantni; Reference: D.1.4.2; CZ_M2 - Plocha: 60.06; Způsob stanovení plochy: 3D plocha TIN povrchu
dopravní značení-vodorovné dopravní značení-V4 | no | -1710876993 | no | dopravní značení-vodorovné dopravní značení-V4 | vdz | ((-639651.809415014,-1063561.15461072,228.875658882425),(-639332.466834197,-1063259.13407419,230.469579143284)) | 7 | dopravní značení-vodorovné dopravní značení | Barva_7 | 255;255;255 | P10 | 0.39 | 154.88 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | Description: Popis; Properties - Description: Popis; CZ_S2 - Typ stavebního výrobku: VDZ; Stavební výrobek: V4 (0,125); Specifikace: barva; Podrobná specifikace: nerelevantni; Reference: D.1.4.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M1 - Délka: 153.1; Způsob stanovení délky: Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V4 plast | no | -738028746 | no | dopravní značení-vodorovné dopravní značení-V4 plast | vdz | ((-639651.809415014,-1063561.15461072,228.875658882425),(-639332.466834197,-1063259.13407419,230.469579143284)) | 7 | dopravní značení-vodorovné dopravní značení | Barva_7 | 255;255;255 | P10 | 0.39 | 154.88 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 | Description: Popis; Properties - Description: Popis; CZ_S2 - Typ stavebního výrobku: VDZ; Stavební výrobek: V4 (0,125); Specifikace: plast; Podrobná specifikace: nerelevantni; Reference: D.1.4.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M1 - Délka: 153.1; Způsob stanovení délky: Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V4 (1) | no | -1395191082 | no | dopravní značení-vodorovné dopravní značení-V4 (1) | vdz | ((-639651.809415014,-1063561.15461072,228.875658882425),(-639332.466834197,-1063259.13407419,230.469579143284)) | 7 | dopravní značení-vodorovné dopravní značení | Barva_7 | 255;255;255 | P10 | 0.39 | 154.88 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | Description: Popis; Properties - Description: Popis; CZ_S2 - Typ stavebního výrobku: VDZ; Stavební výrobek: V4 (0,125); Specifikace: barva; Podrobná specifikace: nerelevantni; Reference: D.1.4.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M1 - Délka: 159.3; Způsob stanovení délky: Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V4 plast (1) | no | 1285435534 | no | dopravní značení-vodorovné dopravní značení-V4 plast (1) | vdz | ((-639651.809415014,-1063561.15461072,228.875658882425),(-639332.466834197,-1063259.13407419,230.469579143284)) | 7 | dopravní značení-vodorovné dopravní značení | Barva_7 | 255;255;255 | P10 | 0.39 | 154.88 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 | Description: Popis; Properties - Description: Popis; CZ_S2 - Typ stavebního výrobku: VDZ; Stavební výrobek: V4 (0,125); Specifikace: plast; Podrobná specifikace: nerelevantni; Reference: D.1.4.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M1 - Délka: 159.3; Způsob stanovení délky: Délka 3D křivky
