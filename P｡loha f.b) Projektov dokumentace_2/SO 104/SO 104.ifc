Properties of the parts of a building model (IFC4X3_ADD2), part 1 of 2

# File
Description: ViewDefinition [Ifc4X3NotAssigned]
File name: D:\_Projekty\2017_07 - SÚS Obchvat Dašic\4_PDPS\BIM\IFC\SO 104.ifc
Time: 2025-05-26T08:47:39
Author: Michal Švarc
Organization: DESKTOP-47J51D1
Written by: GeometryGymIFCcore v24.8.23.0 by Geometry Gym Pty Ltd built 2024-08-23T03:53:20
Made in: Civil 3D 2024 IfcInfra Plugin v13.6.170.0
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcProject, SO 104
Summary - Title: CAD Studio Silniční šablona; Author: Martin Folber, Ondřej Vojtěchovský, Jakub Kareš; HyperlinkBase: www.cadstudio.cz
Custom_Properties - Investor: Správa a údržba silnic Pardubického kraje, Doubravice 98, 533 53 Pardubice; Stupeň PD: DÚSP; Příloha č.: 2.; Část: D; Datum PD: 02.2022; Místo: Pardubický kraj/obec

# IfcAnnotation: Breakline
In: UnknownName
Description: Nastavit povinnou spojnici 1; PredefinedType: USERDEFINED
Breakline Properties - BreaklineType: Standard; MidOrdinateDistance: 1 m

# IfcBuiltElement (146)
In: UnknownName
Properties - ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: no; IsModifiedGraphics: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no; IsNull: no; UsesGraphicsCache: yes; CloneMeForDragging: yes
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
General - Linetype: ByLayer; LinetypeScale: 1; Visible: yes
Geometry - IsPlanar: no
CZ_F1 - Fáze: trvalý stav
CZ_E1 - Datum zahájení prací: 01.05.2025; Datum dokončení: 30.06.2027; Doba trvání: 790; Datum uvedení do provozu: 01.07.2027; Stavební postup / etapa výstavby: nerelevantni
Name | Area | NumChanges | RecordHistory = ShowHistory | Bounds | ColorIndex | Layer | PlotStyleName | podrobná specifikace | CZ_S1, Reference | Materiál | specifikace | Objem | Způsob stanovení objemu | Označení stavebního objektu | Označení podobjektu = Označení části objektu | CZ_I1, Fáze projektu | Název stavebního objektu | CZ_I1, Klasifikační systém | CZ_I1, Staničení od | CZ_I1, Staničení do | CZ_I1, Označení elementu | Skupina elementů | CZ_I1, Označení položky | CZ_I1, Označení šablony vlastností | Skupina přesnosti | Textura / barva | Tloušťka
zemní práce-zemní krajnice a dosypávky | 0.0552927 | 1 | no | ((-639434.5243449,-1063423.65605881,229.660000000001),(-639434.303471648,-1063423.26755453,229.891333864967)) | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.4.4 | nenamrzavý materiál | VL 1 | 0 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.12396 | 0.12433 | zemní krajnice a dosypávky | zemní práce | 173103 | I1+S1+E1+Z1+M3+F1 | P100 | 128;128;128
zemní práce-zemní krajnice a dosypávky | 2.43219 | 1 | no | ((-639439.330296056,-1063419.29330867,229.66),(-639437.345755975,-1063417.87605522,229.967493431203)) | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.4.4 | nenamrzavý materiál | VL 1 | 0.0594798 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.11877 | 0.11925 | zemní krajnice a dosypávky | zemní práce | 173103 | I1+S1+E1+Z1+M3+F1 | P100 | 128;128;128
vozovka_chodník-obrusná vrstva | 976.551 | 1 | no | ((-639549.300520051,-1063460.36530475,229.54588098916),(-639434.727077543,-1063361.22402202,230.449579143284)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.4.4 | ACO 11 50/70 | ČSN EN 13 108-1 | 19.2637 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0 | 0.1562 | obrusná vrstva | vozovka/chodník | 574A03 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.04
vozovka_chodník-obrusná vrstva | 955.311 | 1 | no | ((-639550.535706193,-1063460.79888886,229.54588098916),(-639437.695579661,-1063363.68101514,230.418211609592)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.4.4 | ACO 11 50/70 | ČSN EN 13 108-1 | 18.8436 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0 | 0.1562 | obrusná vrstva | vozovka/chodník | 574A03 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.04
vozovka_chodník-podkladní asfaltová vrstva | 986.193 | 1 | no | ((-639549.300520051,-1063460.36530475,229.47588098916),(-639434.727077543,-1063361.22402202,230.409579143284)) | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.4.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | 33.7115 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0 | 0.1562 | podkladní asfaltová vrstva | vozovka/chodník | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 964.758 | 1 | no | ((-639550.535706193,-1063460.79888886,229.47588098916),(-639437.695579661,-1063363.68101514,230.378211609592)) | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.4.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | 32.9763 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0 | 0.1562 | podkladní asfaltová vrstva | vozovka/chodník | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.07
vozovka_chodník-horní podkladní vrstva | 1011.91 | 1 | no | ((-639549.300520051,-1063460.36530475,229.32588098916),(-639434.727077543,-1063361.22402202,230.339579143284)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.4.4 | MZK | ČSN 73 6126-1 | 72.2389 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0 | 0.1562 | horní podkladní vrstva | vozovka/chodník | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.15
vozovka_chodník-horní podkladní vrstva | 989.952 | 1 | no | ((-639550.535706193,-1063460.79888886,229.32588098916),(-639437.695579661,-1063363.68101514,230.308211609592)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.4.4 | MZK | ČSN 73 6126-1 | 70.6636 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0 | 0.1562 | horní podkladní vrstva | vozovka/chodník | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.15
vozovka_chodník-spodní podkladní vrstva | 1029.35 | 1 | no | ((-639549.300520051,-1063460.36530475,229.11213098916),(-639434.727077543,-1063361.22402202,230.189579143284)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.4.4 | ŠDB | ČSN 73 6126-1 | 98.1589 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0 | 0.1562 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.2
vozovka_chodník-spodní podkladní vrstva | 1007.73 | 1 | no | ((-639550.535706193,-1063460.79888886,229.11213098916),(-639437.695579661,-1063363.68101514,230.158211609592)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.4.4 | ŠDB | ČSN 73 6126-1 | 97.0905 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0 | 0.1562 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.2
vozovka_chodník-obrusná vrstva | 2.61224 | 1 | no | ((-639550.544803076,-1063377.26910501,229.545374660046),(-639528.430075822,-1063366.13800826,229.706830892373)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.4.4 | ACO 11 50/70 | ČSN EN 13 108-1 | 0.010022 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0 | 0.02474 | obrusná vrstva | vozovka/chodník | 574A03 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.04
vozovka_chodník-obrusná vrstva | 0.507557 | 1 | no | ((-639525.461516675,-1063380.92250983,229.68261666634),(-639521.162838745,-1063378.74794497,229.74659323375)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.4.4 | ACO 11 50/70 | ČSN EN 13 108-1 | 0.00194476 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.02807 | 0.03288 | obrusná vrstva | vozovka/chodník | 574A03 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.04
vozovka_chodník-obrusná vrstva | 0.369912 | 1 | no | ((-639518.334504489,-1063383.91966993,229.721611773905),(-639515.200982883,-1063382.33085556,229.779213244005)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.4.4 | ACO 11 50/70 | ČSN EN 13 108-1 | 0.00141652 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.03605 | 0.03955 | obrusná vrstva | vozovka/chodník | 574A03 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.04
vozovka_chodník-podkladní asfaltová vrstva | 8.05983 | 1 | no | ((-639550.583180551,-1063377.34544426,229.473238584097),(-639528.430075822,-1063366.13800826,229.666830892373)) | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.4.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | 0.152366 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0 | 0.02474 | podkladní asfaltová vrstva | vozovka/chodník | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 1.57393 | 1 | no | ((-639525.49989415,-1063380.99884909,229.610480590391),(-639521.162838745,-1063378.74794497,229.70659323375)) | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.4.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | 0.0295665 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.02807 | 0.03288 | podkladní asfaltová vrstva | vozovka/chodník | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 1.14976 | 1 | no | ((-639518.372881964,-1063383.99600919,229.649475697956),(-639515.200982883,-1063382.33085556,229.739213244005)) | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.4.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | 0.0215355 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.03605 | 0.03955 | podkladní asfaltová vrstva | vozovka/chodník | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.07
vozovka_chodník-horní podkladní vrstva | 26.7269 | 1 | no | ((-639550.733094524,-1063377.64364839,229.314894428253),(-639528.430075822,-1063366.13800826,229.596830892373)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.4.4 | MZK | ČSN 73 6126-1 | 1.19718 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0 | 0.02474 | horní podkladní vrstva | vozovka/chodník | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.15
vozovka_chodník-horní podkladní vrstva | 5.26434 | 1 | no | ((-639525.649808123,-1063381.29705321,229.452136434547),(-639521.162838745,-1063378.74794497,229.63659323375)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.4.4 | MZK | ČSN 73 6126-1 | 0.232312 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.02807 | 0.03288 | horní podkladní vrstva | vozovka/chodník | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.15
vozovka_chodník-horní podkladní vrstva | 3.8607 | 1 | no | ((-639518.522795937,-1063384.29421331,229.491131542111),(-639515.200982883,-1063382.33085556,229.669213244005)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.4.4 | MZK | ČSN 73 6126-1 | 0.16921 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.03605 | 0.03955 | horní podkladní vrstva | vozovka/chodník | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.15
vozovka_chodník-spodní podkladní vrstva | 72.5774 | 1 | no | ((-639551.129211845,-1063378.43159241,229.072489825222),(-639528.430075822,-1063366.13800826,229.446830892373)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.4.4 | ŠDB | ČSN 73 6126-1 | 5.26703 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0 | 0.02474 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.2
vozovka_chodník-spodní podkladní vrstva | 14.4267 | 1 | no | ((-639526.045925444,-1063382.08499723,229.209731831516),(-639521.162838745,-1063378.74794497,229.48659323375)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.4.4 | ŠDB | ČSN 73 6126-1 | 1.02206 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.02807 | 0.03288 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.2
vozovka_chodník-spodní podkladní vrstva | 10.6237 | 1 | no | ((-639518.918913258,-1063385.08215733,229.248726939081),(-639515.200982883,-1063382.33085556,229.519213244005)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.4.4 | ŠDB | ČSN 73 6126-1 | 0.744445 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.03605 | 0.03955 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.2
zemní práce-rozprostření ornice (ohumusovani) | 119.344 | 1 | no | ((-639551.809415014,-1063379.43363589,228.711785244479),(-639528.748522996,-1063366.77145328,229.499632774852)) | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.4.4 | ornice | nerelevantni | 7.85188 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0 | 0.02474 | rozprostření ornice (ohumusovan)) | zemní práce | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | P100 | 165;207;99 | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 22.0342 | 1 | no | ((-639526.54557363,-1063383.08234686,228.849027250773),(-639521.481285919,-1063379.38138999,229.539395116229)) | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.4.4 | ornice | nerelevantni | 1.40867 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.02807 | 0.03288 | rozprostření ornice (ohumusovan)) | zemní práce | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | P100 | 165;207;99 | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 15.9812 | 1 | no | ((-639519.419663637,-1063386.08232125,228.888022358338),(-639515.519430058,-1063382.96430058,229.572015126484)) | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.4.4 | ornice | nerelevantni | 1.01021 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.03605 | 0.03955 | rozprostření ornice (ohumusovan)) | zemní práce | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | P100 | 165;207;99 | 0.15
zemní práce-zemní krajnice a dosypávky | 37.2911 | 1 | no | ((-639550.985798865,-1063378.14631985,229.232136085668),(-639528.56211898,-1063366.40066432,229.532833344597)) | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.4.4 | nenamrzavý materiál | VL 1 | 1.36739 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0 | 0.02474 | zemní krajnice a dosypávky | zemní práce | 173103 | I1+S1+E1+Z1+M3+F1 | P100 | 128;128;128
zemní práce-zemní krajnice a dosypávky | 7.3254 | 1 | no | ((-639525.902512464,-1063381.79972468,229.369378091962),(-639521.294881902,-1063379.01060103,229.572595685974)) | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.4.4 | nenamrzavý materiál | VL 1 | 0.265342 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.02807 | 0.03288 | zemní krajnice a dosypávky | zemní práce | 173103 | I1+S1+E1+Z1+M3+F1 | P100 | 128;128;128
zemní práce-zemní krajnice a dosypávky | 5.36566 | 1 | no | ((-639518.775500278,-1063384.79688477,229.408373199527),(-639515.333026041,-1063382.59351162,229.60521569623)) | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.4.4 | nenamrzavý materiál | VL 1 | 0.193269 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.03605 | 0.03955 | zemní krajnice a dosypávky | zemní práce | 173103 | I1+S1+E1+Z1+M3+F1 | P100 | 128;128;128
zemní práce-rozprostření ornice (ohumusovani) | 12.442 | 1 | no | ((-639529.483847775,-1063380.91796309,228.832931078665),(-639525.777538345,-1063377.90245714,229.515888375815)) | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.4.4 | ornice | nerelevantni | 0.754374 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.02478 | 0.02807 | rozprostření ornice (ohumusovan)) | zemní práce | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | P100 | 165;207;99 | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 11.3147 | 1 | no | ((-639522.21538229,-1063384.47233271,228.872697488359),(-639518.689879784,-1063381.55623577,229.554668161887)) | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.4.4 | ornice | nerelevantni | 0.681103 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.03292 | 0.036 | rozprostření ornice (ohumusovan)) | zemní práce | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | P100 | 165;207;99 | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 476.391 | 1 | no | ((-639516.251323061,-1063461.15461072,228.687953784112),(-639441.365623964,-1063384.5556646,230.13601349208)) | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.4.4 | ornice | nerelevantni | 7.85188 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.03959 | 0.1562 | rozprostření ornice (ohumusovan)) | zemní práce | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | P100 | 165;207;99 | 0.15
vozovka_chodník-obrusná vrstva | 0.347555 | 1 | no | ((-639528.403363022,-1063378.76268634,229.666520494232),(-639525.459091171,-1063377.26901212,229.72308649332)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.4.4 | ACO 11 50/70 | ČSN EN 13 108-1 | 0.00133072 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.02478 | 0.02807 | obrusná vrstva | vozovka/chodník | 574A03 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.04
vozovka_chodník-obrusná vrstva | 0.326253 | 1 | no | ((-639521.135382391,-1063382.32581298,229.706286903927),(-639518.37143261,-1063380.92279074,229.7618662794)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.4.4 | ACO 11 50/70 | ČSN EN 13 108-1 | 0.00124896 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.03292 | 0.036 | obrusná vrstva | vozovka/chodník | 574A03 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.04
vozovka_chodník-obrusná vrstva | 11.9955 | 1 | no | ((-639515.169013638,-1063460.80181601,229.738931606254),(-639440.664081778,-1063383.92221957,230.343211609592)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.4.4 | ACO 11 50/70 | ČSN EN 13 108-1 | 0.0460895 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.03959 | 0.1562 | obrusná vrstva | vozovka/chodník | 574A03 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.04
vozovka_chodník-podkladní asfaltová vrstva | 1.08086 | 1 | no | ((-639528.441740497,-1063378.8390256,229.594384418283),(-639525.459091171,-1063377.26901212,229.68308649332)) | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.4.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | 0.0202311 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.02478 | 0.02807 | podkladní asfaltová vrstva | vozovka/chodník | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 1.01522 | 1 | no | ((-639521.173759866,-1063382.40215223,229.634150827977),(-639518.37143261,-1063380.92279074,229.7218662794)) | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.4.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | 0.0189882 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.03292 | 0.036 | podkladní asfaltová vrstva | vozovka/chodník | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 36.9445 | 1 | no | ((-639515.207391113,-1063460.81416492,229.666795530305),(-639440.664081778,-1063383.92221957,230.303211609592)) | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.4.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | 0.698982 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.03959 | 0.1562 | podkladní asfaltová vrstva | vozovka/chodník | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.07
vozovka_chodník-horní podkladní vrstva | 3.63272 | 1 | no | ((-639528.591654471,-1063379.13722972,229.436040262439),(-639525.459091171,-1063377.26901212,229.61308649332)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.4.4 | MZK | ČSN 73 6126-1 | 0.158961 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.02478 | 0.02807 | horní podkladní vrstva | vozovka/chodník | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.15
vozovka_chodník-horní podkladní vrstva | 3.41549 | 1 | no | ((-639521.32367384,-1063382.70035636,229.475806672133),(-639518.37143261,-1063380.92279074,229.6518662794)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.4.4 | MZK | ČSN 73 6126-1 | 0.149195 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.03292 | 0.036 | horní podkladní vrstva | vozovka/chodník | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.15
vozovka_chodník-horní podkladní vrstva | 122.69 | 1 | no | ((-639515.357305087,-1063460.8624035,229.50845137446),(-639440.664081778,-1063383.92221957,230.233211609592)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.4.4 | MZK | ČSN 73 6126-1 | 5.50505 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.03959 | 0.1562 | horní podkladní vrstva | vozovka/chodník | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.15
vozovka_chodník-spodní podkladní vrstva | 10.006 | 1 | no | ((-639528.987771792,-1063379.92517374,229.193635659408),(-639525.459091171,-1063377.26901212,229.46308649332)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.4.4 | ŠDB | ČSN 73 6126-1 | 0.699354 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.02478 | 0.02807 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.2
vozovka_chodník-spodní podkladní vrstva | 9.41746 | 1 | no | ((-639521.719791161,-1063383.48830038,229.233402069101),(-639518.37143261,-1063380.92279074,229.5018662794)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.4.4 | ŠDB | ČSN 73 6126-1 | 0.656389 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.03292 | 0.036 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.2
vozovka_chodník-spodní podkladní vrstva | 331.277 | 1 | no | ((-639515.753422408,-1063460.99024856,229.266046771431),(-639440.664081778,-1063383.92221957,230.083211609592)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.4.4 | ŠDB | ČSN 73 6126-1 | 23.9457 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.03959 | 0.1562 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.2
zemní práce-zemní krajnice a dosypávky | 5.04735 | 1 | no | ((-639528.844358811,-1063379.63990119,229.353281919854),(-639525.591134329,-1063377.53166818,229.549088945573)) | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.4.4 | nenamrzavý materiál | VL 1 | 0.181562 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.02478 | 0.02807 | zemní krajnice a dosypávky | zemní práce | 173103 | I1+S1+E1+Z1+M3+F1 | P100 | 128;128;128
zemní práce-zemní krajnice a dosypávky | 4.74406 | 1 | no | ((-639521.57637818,-1063383.20302782,229.393048329546),(-639518.503475768,-1063381.18544681,229.587868731638)) | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.4.4 | nenamrzavý materiál | VL 1 | 0.170408 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.03292 | 0.036 | zemní krajnice a dosypávky | zemní práce | 173103 | I1+S1+E1+Z1+M3+F1 | P100 | 128;128;128
zemní práce-zemní krajnice a dosypávky | 171.592 | 1 | no | ((-639515.610009427,-1063460.94410184,229.425693031878),(-639440.954974124,-1063384.18487564,230.169214061825)) | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.4.4 | nenamrzavý materiál | VL 1 | 6.39641 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.03959 | 0.1562 | zemní krajnice a dosypávky | zemní práce | 173103 | I1+S1+E1+Z1+M3+F1 | P100 | 128;128;128
vozovka_chodník-obrusná vrstva | 1.12272 | 1 | no | ((-639548.06533391,-1063365.99832461,229.545374660046),(-639538.559345638,-1063361.20592679,229.637842777853)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.4.4 | ACO 11 50/70 | ČSN EN 13 108-1 | 0.00430559 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0 | 0.01063 | obrusná vrstva | vozovka/chodník | 574A03 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.04
vozovka_chodník-obrusná vrstva | 1.10282 | 1 | no | ((-639515.010997108,-1063382.5308158,229.72622988878),(-639505.673438185,-1063377.82309123,229.817776453434)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.4.4 | ACO 11 50/70 | ČSN EN 13 108-1 | 0.00422923 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.037 | 0.04744 | obrusná vrstva | vozovka/chodník | 574A03 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.04
vozovka_chodník-obrusná vrstva | 0.480638 | 1 | no | ((-639488.562652125,-1063393.13295038,229.870940748059),(-639484.46710609,-1063391.11927383,229.947519538473)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.4.4 | ACO 11 50/70 | ČSN EN 13 108-1 | 0.00184077 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.0666 | 0.07114 | obrusná vrstva | vozovka/chodník | 574A03 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.04
vozovka_chodník-podkladní asfaltová vrstva | 3.46964 | 1 | no | ((-639548.06533391,-1063365.99832461,229.473238584097),(-639538.520968164,-1063361.12958753,229.597842777853)) | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.4.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | 0.0654585 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0 | 0.01063 | podkladní asfaltová vrstva | vozovka/chodník | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 3.40833 | 1 | no | ((-639515.010997108,-1063382.5308158,229.654093812831),(-639505.63506071,-1063377.74675197,229.777776453434)) | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.4.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | 0.0642976 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.037 | 0.04744 | podkladní asfaltová vrstva | vozovka/chodník | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 1.49104 | 1 | no | ((-639488.562652125,-1063393.13295038,229.79880467211),(-639484.428678733,-1063391.04293458,229.907519538473)) | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.4.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | 0.0279961 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.0666 | 0.07114 | podkladní asfaltová vrstva | vozovka/chodník | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.07
vozovka_chodník-horní podkladní vrstva | 11.5375 | 1 | no | ((-639548.06533391,-1063365.99832461,229.314894428253),(-639538.37105419,-1063360.83138341,229.527842777853)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.4.4 | MZK | ČSN 73 6126-1 | 0.514325 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0 | 0.01063 | horní podkladní vrstva | vozovka/chodník | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.15
vozovka_chodník-horní podkladní vrstva | 11.3346 | 1 | no | ((-639515.010997108,-1063382.5308158,229.495749656987),(-639505.485146736,-1063377.44854785,229.707776453434)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.4.4 | MZK | ČSN 73 6126-1 | 0.505204 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.037 | 0.04744 | horní podkladní vrstva | vozovka/chodník | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.15
vozovka_chodník-horní podkladní vrstva | 4.98651 | 1 | no | ((-639488.562652125,-1063393.13295038,229.640460516266),(-639484.279280906,-1063390.74473045,229.837519538473)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.4.4 | MZK | ČSN 73 6126-1 | 0.219858 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.0666 | 0.07114 | horní podkladní vrstva | vozovka/chodník | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.15
vozovka_chodník-spodní podkladní vrstva | 31.4231 | 1 | no | ((-639548.06533391,-1063365.99832461,229.072489825222),(-639537.974936869,-1063360.04343939,229.377842777853)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.4.4 | ŠDB | ČSN 73 6126-1 | 2.26279 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0 | 0.01063 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.2
vozovka_chodník-spodní podkladní vrstva | 34.9467 | 1 | no | ((-639515.010997108,-1063382.5308158,229.250691247559),(-639505.030167706,-1063376.58156887,229.557776453434)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.4.4 | ŠDB | ČSN 73 6126-1 | 2.45383 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.037 | 0.04744 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.2
vozovka_chodník-spodní podkladní vrstva | 13.6268 | 1 | no | ((-639488.562652125,-1063393.13295038,229.398055913235),(-639483.892005935,-1063389.95678643,229.687519538473)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.4.4 | ŠDB | ČSN 73 6126-1 | 0.96227 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.0666 | 0.07114 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.2
zemní práce-rozprostření ornice (ohumusovani) | 39.9046 | 1 | no | ((-639547.746886736,-1063365.36487959,228.711785244479),(-639537.543015172,-1063359.13407419,229.430644660332)) | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.4.4 | ornice | nerelevantni | 2.50459 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0 | 0.01063 | rozprostření ornice (ohumusovan)) | zemní práce | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | P100 | 165;207;99 | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 11.1088 | 1 | no | ((-639514.690919185,-1063378.1757877,228.888763189744),(-639511.657061676,-1063375.54305371,229.569531286346)) | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.4.4 | ornice | nerelevantni | 0.677653 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.037 | 0.03917 | rozprostření ornice (ohumusovan)) | zemní práce | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | P100 | 165;207;99 | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 17.3082 | 1 | no | ((-639488.24420495,-1063392.49989622,229.037351332492),(-639483.458409008,-1063389.06932003,229.740321420952)) | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.4.4 | ornice | nerelevantni | 1.06953 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.0666 | 0.07114 | rozprostření ornice (ohumusovan)) | zemní práce | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | P100 | 165;207;99 | 0.15
zemní práce-zemní krajnice a dosypávky | 16.0838 | 1 | no | ((-639547.933290752,-1063365.73566855,229.232136085668),(-639538.11834985,-1063360.32871194,229.463845230077)) | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.4.4 | nenamrzavý materiál | VL 1 | 0.587452 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0 | 0.01063 | zemní krajnice a dosypávky | zemní práce | 173103 | I1+S1+E1+Z1+M3+F1 | P100 | 128;128;128
zemní práce-zemní krajnice a dosypávky | 17.7794 | 1 | no | ((-639514.87895395,-1063382.26815974,229.411671271164),(-639505.203224628,-1063376.90656321,229.643778905658)) | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.4.4 | nenamrzavý materiál | VL 1 | 0.651681 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.037 | 0.04744 | zemní krajnice a dosypávky | zemní práce | 173103 | I1+S1+E1+Z1+M3+F1 | P100 | 128;128;128
zemní práce-zemní krajnice a dosypávky | 6.89128 | 1 | no | ((-639488.430608967,-1063392.86890968,229.557702173682),(-639484.033780185,-1063390.24205899,229.7733834127)) | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.4.4 | nenamrzavý materiál | VL 1 | 0.247632 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.0666 | 0.07114 | zemní krajnice a dosypávky | zemní práce | 173103 | I1+S1+E1+Z1+M3+F1 | P100 | 128;128;128
zemní práce-rozprostření ornice (ohumusovani) | 92.2442 | 1 | no | ((-639538.244539033,-1063377.20204842,228.763776887135),(-639513.861211246,-1063363.961288,229.559221702344)) | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.4.4 | ornice | nerelevantni | 4.28038 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.01064 | 0.03699 | rozprostření ornice (ohumusovan)) | zemní práce | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | P100 | 165;207;99 | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 68.5787 | 1 | no | ((-639505.355980125,-1063390.50044684,228.937974321284),(-639487.529915963,-1063380.13140641,229.704211115107)) | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.4.4 | ornice | nerelevantni | 4.28038 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.04744 | 0.06659 | rozprostření ornice (ohumusovan)) | zemní práce | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | P100 | 165;207;99 | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 149.342 | 1 | no | ((-639441.51054948,-1063459.82925228,228.975600799387),(-639432.466834197,-1063429.18290446,230.242381025762)) | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.4.4 | ornice | nerelevantni | 9.83915 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.12672 | 0.1562 | rozprostření ornice (ohumusovan)) | zemní práce | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | P100 | 165;207;99 | 0.15
vozovka_chodník-obrusná vrstva | 2.78253 | 1 | no | ((-639538.562986207,-1063377.83872822,229.597366302703),(-639515.006790079,-1063365.98297239,229.76670946329)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.4.4 | ACO 11 50/70 | ČSN EN 13 108-1 | 0.0106755 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.01064 | 0.03699 | obrusná vrstva | vozovka/chodník | 574A03 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.04
vozovka_chodník-obrusná vrstva | 2.02175 | 1 | no | ((-639505.676722992,-1063391.13389187,229.777301924815),(-639488.56047197,-1063382.51564244,229.911409232623)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.4.4 | ACO 11 50/70 | ČSN EN 13 108-1 | 0.00775585 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.04744 | 0.06659 | obrusná vrstva | vozovka/chodník | 574A03 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.04
vozovka_chodník-obrusná vrstva | 9.18831 | 1 | no | ((-639484.470905324,-1063459.93172064,229.907206166166),(-639434.707037022,-1063393.11741955,230.449579143284)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.4.4 | ACO 11 50/70 | ČSN EN 13 108-1 | 0.0349427 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.07115 | 0.1562 | obrusná vrstva | vozovka/chodník | 574A03 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.04
vozovka_chodník-podkladní asfaltová vrstva | 8.5846 | 1 | no | ((-639538.562986207,-1063377.83872822,229.525230226753),(-639514.968412604,-1063365.90663314,229.72670946329)) | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.4.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | 0.162301 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.01064 | 0.03699 | podkladní asfaltová vrstva | vozovka/chodník | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 6.24015 | 1 | no | ((-639505.676722992,-1063391.13389187,229.705165848866),(-639488.522094495,-1063382.43930318,229.871409232623)) | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.4.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | 0.117913 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.04744 | 0.06659 | podkladní asfaltová vrstva | vozovka/chodník | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 28.4335 | 1 | no | ((-639484.470905324,-1063459.93172064,229.83553680465),(-639434.622491076,-1063393.04121458,230.41305475304)) | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.4.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | 0.538521 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.07115 | 0.1562 | podkladní asfaltová vrstva | vozovka/chodník | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.07
vozovka_chodník-horní podkladní vrstva | 28.4635 | 1 | no | ((-639538.562986207,-1063377.83872822,229.366886070909),(-639514.818498631,-1063365.60842901,229.65670946329)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.4.4 | MZK | ČSN 73 6126-1 | 1.27525 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.01064 | 0.03699 | horní podkladní vrstva | vozovka/chodník | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.15
vozovka_chodník-horní podkladní vrstva | 20.7054 | 1 | no | ((-639505.676722992,-1063391.13389187,229.546821693022),(-639488.372180522,-1063382.14109906,229.801409232623)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.4.4 | MZK | ČSN 73 6126-1 | 0.926476 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.04744 | 0.06659 | horní podkladní vrstva | vozovka/chodník | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.15
vozovka_chodník-horní podkladní vrstva | 92.0695 | 1 | no | ((-639484.470905324,-1063459.93172064,229.679046776257),(-639434.292229152,-1063392.74495017,230.349762070114)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.4.4 | MZK | ČSN 73 6126-1 | 4.15892 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.07115 | 0.1562 | horní podkladní vrstva | vozovka/chodník | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.15
vozovka_chodník-spodní podkladní vrstva | 77.4578 | 1 | no | ((-639538.562986207,-1063377.83872822,229.124481467879),(-639514.382772149,-1063364.82048499,229.50670946329)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.4.4 | ŠDB | ČSN 73 6126-1 | 5.61999 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.01064 | 0.03699 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.2
vozovka_chodník-spodní podkladní vrstva | 56.5871 | 1 | no | ((-639505.676722992,-1063391.13389187,229.300497588328),(-639487.976063201,-1063381.23642548,229.651409232623)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.4.4 | ŠDB | ČSN 73 6126-1 | 4.09382 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.04744 | 0.06659 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.2
vozovka_chodník-spodní podkladní vrstva | 19.5816 | 1 | no | ((-639484.470905324,-1063396.13036366,229.446172845358),(-639477.69902482,-1063391.97696673,229.768362864417)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.4.4 | ŠDB | ČSN 73 6126-1 | 1.37126 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.07115 | 0.07797 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.2
vozovka_chodník-spodní podkladní vrstva | 43.2199 | 1 | no | ((-639437.312865493,-1063459.93172064,229.796702090182),(-639433.416947236,-1063444.84134593,230.083211609592)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.4.4 | ŠDB | ČSN 73 6126-1 | 3.06687 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.14151 | 0.1562 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.2
zemní práce-zemní krajnice a dosypávky | 39.7997 | 1 | no | ((-639538.430943049,-1063377.57607216,229.284127728326),(-639514.546091821,-1063365.10575755,229.592711915522)) | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.4.4 | nenamrzavý materiál | VL 1 | 1.45968 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.01064 | 0.03699 | zemní krajnice a dosypávky | zemní práce | 173103 | I1+S1+E1+Z1+M3+F1 | P100 | 128;128;128
zemní práce-zemní krajnice a dosypávky | 29.0399 | 1 | no | ((-639505.544679834,-1063390.8712358,229.46211775235),(-639488.119476181,-1063381.5804843,229.737411684857)) | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.4.4 | nenamrzavý materiál | VL 1 | 1.06401 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.04744 | 0.06659 | zemní krajnice a dosypávky | zemní práce | 173103 | I1+S1+E1+Z1+M3+F1 | P100 | 128;128;128
zemní práce-zemní krajnice a dosypávky | 148.939 | 1 | no | ((-639484.337755709,-1063459.88923245,229.596019810159),(-639433.73288741,-1063392.25810878,230.273677019881)) | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.4.4 | nenamrzavý materiál | VL 1 | 5.9886 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.07115 | 0.1562 | zemní krajnice a dosypávky | zemní práce | 173103 | I1+S1+E1+Z1+M3+F1 | P100 | 128;128;128
vozovka_chodník-obrusná vrstva | 122.628 | 1 | no | ((-639447.535389179,-1063430.50341949,229.94),(-639434.575909743,-1063418.39554252,230.45)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.4.2 | ACO 16 50/70 | ČSN EN 13 108-1 | 3.60378 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 116.4 | 126.7 | obrusná vrstva | vozovka/chodník | 574A05 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.06
vozovka_chodník-horní podkladní vrstva | 122.231 | 1 | no | ((-639447.535389179,-1063430.50341949,229.89),(-639434.575909743,-1063418.39554252,230.39)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.4.2 | Recyklovaný materiál | TP 210 | 3.00315 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 116.4 | 126.7 | horní podkladní vrstva | vozovka/chodník | 56360 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.05
vozovka_chodník-spodní podkladní vrstva | 129.368 | 1 | no | ((-639447.535389179,-1063430.50341949,229.66),(-639434.575909743,-1063418.39554252,230.34)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.4.4 | ŠDB | ČSN 73 6126-1 | 13.8145 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 116.4 | 126.7 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 128;128;128 | 0.23
propustky-zpevnění dlažbou | 5.65633 | 1 | no | ((-639507.22893212,-1063380.2951274,228.88),(-639505.351663771,-1063378.41682131,229.653280315423)) | 8 | propustky-zpevnění dlažbou | Barva_8 | nerelevantni | D.1.4.4 | lomový kámen, spárováno MC | nerelevantni |  |  | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 44.77 | 46.17 | zpevnění dlažbou | propustky | 465512 | I1+S1+E1+Z1+M2+F1 | P50 | 128;128;128 | CZ_M2 - Způsob stanovení plochy: 3D plocha TIN povrchu; Plocha: 1.74884
propustky-lože | 4.90211 | 1 | no | ((-639507.22893212,-1063380.2951274,228.78),(-639505.351663771,-1063378.41682131,229.45328031546)) | 16 | propustky-lože | Barva_16 | nerelevantni | D.1.4.4 | beton | nerelevantni | 0.179205 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 44.77 | 46.17 | lože | propustky | 45131A | I1+S1;4+E1+Z1+M3+F1 | P50 | 128;0;0 | CZ_S4 - Beton: C20/25nXF3; Specifikace: nerelevantni; Typ betonářské vyztuže: nerelevantni; Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.1.4.4; Návrhová životnost: 25 let
propustky-zásypy a obsypy | 32.3753 | 2 | no | ((-639511.875012172,-1063380.23566501,228.740006280751),(-639505.699218827,-1063375.91272609,229.567601689455)) | 40 | propustky-zásypy a obsypy | Barva_40 | vhodná nebo podmínečně vhodná | D.1.4.4 | zemina | ČSN 73 6133 | 3.4627 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 39.66 | 45.67 | zásypy a obsypy | propustky | 17511 | I1+S1;3+E1+Z1+M3+F1 | P50 | 255;165;0 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
propustky-obetonování | 13.965 | 2 | no | ((-639511.675076151,-1063379.84778327,228.890002947487),(-639505.909786008,-1063376.34848808,229.274364665384)) | 8 | propustky-obetonování | Barva_8 | nerelevantni | D.1.4.4 | beton C20/25nXF3 | nerelevantni | 1.11789 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 39.67 | 45.67 | obetonování | propustky | 89952A | I1+S1+E1+Z1+M3+F1 | P50 | 128;128;128
propustky-podkladní vrstva | 17.3385 | 2 | no | ((-639511.775296758,-1063380.05003192,228.740006280866),(-639505.807443394,-1063376.1473745,228.930002947626)) | 2 | propustky-podkladní vrstva | Barva_2 | nerelevantni | D.1.4.4 | štěrkodrť fr. 0/32 | nerelevantni | 1.08346 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 39.67 | 45.67 | podkladní vrstva | propustky | 45152 | I1+S1+E1+Z1+M3+F1 | P50 | 255;255;0
propustky-lože | 4.93891 | 1 | no | ((-639512.234650115,-1063377.77878852,228.74),(-639510.357381766,-1063375.90033339,229.447305200598)) | 16 | propustky-lože | Barva_16 | nerelevantni | D.1.4.4 | beton | nerelevantni | 0.179201 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 39.17 | 40.56 | lože | propustky | 45131A | I1+S1;4+E1+Z1+M3+F1 | P50 | 128;0;0 | CZ_S4 - Beton: C20/25nXF3; Specifikace: nerelevantni; Typ betonářské vyztuže: nerelevantni; Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.1.4.4; Návrhová životnost: 25 let
propustky-zpevnění dlažbou | 5.7026 | 1 | no | ((-639512.234650115,-1063377.77878852,228.84),(-639510.357381766,-1063375.90033339,229.647305200594)) | 8 | propustky-zpevnění dlažbou | Barva_8 | nerelevantni | D.1.4.4 | lomový kámen, spárováno MC | nerelevantni |  |  | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 39.17 | 40.56 | zpevnění dlažbou | propustky | 465512 | I1+S1+E1+Z1+M2+F1 | P50 | 128;128;128 | CZ_M2 - Způsob stanovení plochy: 3D plocha TIN povrchu; Plocha: 1.75163
propustky-propust | 12.861 | 2 | no | ((-639511.486364455,-1063379.53253217,229.039999614019),(-639506.09875294,-1063376.66864687,229.475611995759)) | 8 | propustky-propust | Barva_8 | nerelevantni | D.1.4.4 | PP | nerelevantni |  |  | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 39.67 | 45.67 | propust | propustky | 87446 | I1+S1;2+E1+Z1+M1+F1 | P10 | 128;128;128 | CZ_S2 - Reference: D.1.4.4; Podrobná specifikace: nerelevantni; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Specifikace: nerelevantni; Typ stavebního výrobku: propustek; Stavební výrobek: PP SN12 DN400; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 6
vozovka_chodník-krytová vrstva nezpevněných vozovek | 34.9891 | 1 | no | ((-639512.709455305,-1063381.7817786,229.45),(-639506.371519613,-1063376.20966624,229.81)) | 36 | vozovka_chodník-krytová vrstva nezpevněných vozovek | Barva_36 | nerelevantni | D.1.4.2 | Recyklovaný materiál | TP 210 | 1.65221 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 39.57 | 45.77 | krytová vrstva nezpevněných vozovek | vozovka/chodník | 56360 | I1+S1+E1+Z1+M3;2&6+F1 | P2 | 125;75;0 | 0.1
zemní práce-rozprostření ornice (ohumusovani) | 7.39258 | 1 | no | ((-639512.734797234,-1063381.29015323,229.19),(-639505.980485807,-1063377.15116625,229.75)) | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.4.4 | ornice | nerelevantni | 0.30584 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 39.17 | 46.17 | rozprostření ornice (ohumusovan)) | zemní práce | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | P100 | 165;207;99 | 0.1
zemní práce-rozprostření ornice (ohumusovani) | 6.97289 | 1 | no | ((-639506.494714863,-1063381.89279236,228.927924995902),(-639504.473732014,-1063379.10204029,229.610168382306)) | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.4.4 | ornice | nerelevantni | 0.408758 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 46.17 | 47.44 | rozprostření ornice (ohumusovan)) | zemní práce | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | P100 | 165;207;99 | 0.1
zemní práce-rozprostření ornice (ohumusovani) | 161.263 | 1 | no | ((-639484.151677655,-1063420.67165052,228.927999745159),(-639445.739812735,-1063391.11721467,230.191447365778)) | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.4.4 | ornice | nerelevantni | 2.50459 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.07115 | 0.1164 | rozprostření ornice (ohumusovan)) | zemní práce | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | P100 | 165;207;99 | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 32.0319 | 1 | no | ((-639441.657292877,-1063430.2018486,228.994169103015),(-639434.303598722,-1063423.61151946,230.41)) | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.4.4 | ornice | nerelevantni | 2.12765 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.12429 | 0.12681 | rozprostření ornice (ohumusovan)) | zemní práce | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | P100 | 165;207;99 | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 18.0552 | 1 | no | ((-639446.914041694,-1063421.73912993,229.423010686089),(-639437.541307622,-1063417.84900814,230.360000000001)) | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.4.4 | ornice | nerelevantni | 1.08695 | řezová metoda | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 0.1164 | 0.11892 | rozprostření ornice (ohumusovan)) | zemní práce | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | P100 | 165;207;99 | 0.15
dopravní značení-svislé dopravní značení | 0.121737 | 2 | yes | ((-639523.742549423,-1063372.92957811,229.677869956836),(-639523.692549423,-1063372.87957811,230.427869956836)) | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  |  |  | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 27.02 | 27.02 | svislé dopravní značení | dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | P10 | 255;255;255 | CZ_S2 - Reference: D.1.4.6; Podrobná specifikace: TP 65; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Specifikace: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.121737 | 2 | yes | ((-639526.662080303,-1063378.7370164,229.67786995684),(-639526.612080303,-1063378.6870164,230.42786995684)) | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  |  |  | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 27.02 | 27.02 | svislé dopravní značení | dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | P10 | 255;255;255 | CZ_S2 - Reference: D.1.4.6; Podrobná specifikace: TP 65; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Specifikace: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.121737 | 2 | yes | ((-639478.955030212,-1063395.2758347,229.976442235937),(-639478.905030212,-1063395.2258347,230.726442235937)) | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  |  |  | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 77.02 | 77.02 | svislé dopravní značení | dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | P10 | 255;255;255 | CZ_S2 - Reference: D.1.4.6; Podrobná specifikace: TP 65; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Specifikace: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.121737 | 2 | yes | ((-639482.181526491,-1063401.37583031,229.917026936253),(-639482.131526491,-1063401.32583031,230.667026936253)) | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  |  |  | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 76.99 | 76.99 | svislé dopravní značení | dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | P10 | 255;255;255 | CZ_S2 - Reference: D.1.4.6; Podrobná specifikace: TP 65; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Specifikace: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.121737 | 2 | yes | ((-639461.208068898,-1063405.81650162,230.243295159052),(-639461.158068898,-1063405.76650162,230.993295159052)) | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  |  |  | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 96.98 | 96.98 | svislé dopravní značení | dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | P10 | 255;255;255 | CZ_S2 - Reference: D.1.4.6; Podrobná specifikace: TP 65; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Specifikace: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.121737 | 2 | yes | ((-639466.12234174,-1063411.99926065,229.933020552649),(-639466.07234174,-1063411.94926065,230.683020552649)) | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  |  |  | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 96.97 | 96.97 | svislé dopravní značení | dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | P10 | 255;255;255 | CZ_S2 - Reference: D.1.4.6; Podrobná specifikace: TP 65; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Specifikace: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.121737 | 2 | yes | ((-639453.374670352,-1063412.98230557,230.312547454796),(-639453.324670352,-1063412.93230557,231.062547454796)) | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  |  |  | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 106.99 | 106.99 | svislé dopravní značení | dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | P10 | 255;255;255 | CZ_S2 - Reference: D.1.4.6; Podrobná specifikace: TP 65; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Specifikace: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.121737 | 2 | yes | ((-639459.252131003,-1063418.40959369,229.962582477714),(-639459.202131003,-1063418.35959369,230.712582477714)) | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  |  |  | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 106.99 | 106.99 | svislé dopravní značení | dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | P10 | 255;255;255 | CZ_S2 - Reference: D.1.4.6; Podrobná specifikace: TP 65; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Specifikace: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.121737 | 2 | yes | ((-639453.454879218,-1063425.76512414,230.01146563187),(-639453.404879218,-1063425.71512414,230.76146563187)) | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  |  |  | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 116.99 | 116.99 | svislé dopravní značení | dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | P10 | 255;255;255 | CZ_S2 - Reference: D.1.4.6; Podrobná specifikace: TP 65; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Specifikace: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.121737 | 2 | yes | ((-639446.804451662,-1063421.31857342,230.361432257635),(-639446.754451662,-1063421.26857342,231.111432257635)) | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  |  |  | SO 104 | nerelevantni | PDPS | Silnice III/322 XX Zminný | OTSKP | 116.99 | 116.99 | svislé dopravní značení | dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | P10 | 255;255;255 | CZ_S2 - Reference: D.1.4.6; Podrobná specifikace: TP 65; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Specifikace: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
