Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [Ifc4X3NotAssigned]
File name: D:\_Projekty\2017_07 - SÚS Obchvat Dašic\4_PDPS\BIM\IFC\SO 106.ifc
Time: 2025-03-20T09:51:50
Author: Michal Švarc
Organization: DESKTOP-47J51D1
Written by: GeometryGymIFCcore v24.8.23.0 by Geometry Gym Pty Ltd built 2024-08-23T03:53:20
Made in: Civil 3D 2024 IfcInfra Plugin v13.6.170.0
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcProject, SO 106
Summary - Title: CAD Studio Silniční šablona; Author: Martin Folber, Ondřej Vojtěchovský, Jakub Kareš; HyperlinkBase: www.cadstudio.cz
Custom_Properties - Investor: Správa a údržba silnic Pardubického kraje, Doubravice 98, 533 53 Pardubice; Stupeň PD: DÚSP; Příloha č.: 2.; Část: D; Datum PD: 02.2022; Místo: Pardubický kraj/obec

# IfcAnnotation: Breakline (4)
In: UnknownName
Description: Nastavit povinnou spojnici 1; PredefinedType: USERDEFINED
Breakline Properties - BreaklineType: Standard; MidOrdinateDistance: 1 m

# IfcBuiltElement (49)
In: UnknownName
Properties - ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: no; IsModifiedGraphics: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no; IsNull: no; UsesGraphicsCache: yes; CloneMeForDragging: yes
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
General - Linetype: ByLayer; LinetypeScale: 1; Visible: yes
Geometry - IsPlanar: no
CZ_E1 - Datum zahájení prací: 01.05.2025; Datum dokončení: 30.06.2027; Doba trvání: 790; Datum uvedení do provozu: 01.07.2027; Stavební postup / etapa výstavby: nerelevantni
CZ_F1 - Fáze: trvalý stav
Name | Area | NumChanges | RecordHistory = ShowHistory | Bounds | ColorIndex | Layer | PlotStyleName | Označení stavebního objektu | Označení podobjektu = Označení části objektu | CZ_I1, Fáze projektu | Název stavebního objektu | CZ_I1, Klasifikační systém | Skupina elementů | CZ_I1, Staničení od | CZ_I1, Staničení do | CZ_I1, Označení elementu | CZ_I1, Označení položky | CZ_I1, Označení šablony vlastností | podrobná specifikace | CZ_S1, Reference | Materiál | specifikace | Skupina přesnosti | Textura / barva | Objem | Způsob stanovení objemu | Tloušťka
vozovka_chodník-krytová vrstva nezpevněných vozovek | 160.756 | 1 | no | ((-642860.365042571,-1062751.79692303,232.489999999944),(-642842.799874951,-1062739.76953644,232.930846925817)) | 36 | vozovka_chodník-krytová vrstva nezpevněných vozovek | Barva_36 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | vozovka/chodník | 481.35 | 505.84 | krytová vrstva nezpevněných vozovek | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.6.4 | MZK | ČSN 73 6126-1 | P2 | 125;75;0 | 15.0487 | řezová metoda | 0.2
vozovka_chodník-spodní podkladní vrstva | 161.517 | 1 | no | ((-642860.364222537,-1062751.79669675,232.275003618347),(-642842.799054917,-1062739.76931016,232.73085054422)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | vozovka/chodník | 481.35 | 505.84 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.6.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 16.1774 | řezová metoda | 0.2
vozovka_chodník-obrusná vrstva | 236.623 | 1 | no | ((-643302.652919771,-1062536.10793401,231.45822050428),(-643285.882043075,-1062523.27898116,231.75)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | vozovka/chodník | 0 | 5.26 | obrusná vrstva | 574A05 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.6.4 | ACO 16 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 7.01052 | řezová metoda | 0.06
vozovka_chodník-horní podkladní vrstva | 236.141 | 1 | no | ((-643302.65271619,-1062536.10819057,231.408222292113),(-643285.881839494,-1062523.27923771,231.690001787833)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | vozovka/chodník | 0 | 5.26 | horní podkladní vrstva | 56360 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.6.4 | Recyklovaný materiál | TP 210 | P2 | 128;128;128 | 5.8421 | řezová metoda | 0.05
vozovka_chodník-spodní podkladní vrstva | 244.817 | 1 | no | ((-643302.652546539,-1062536.10840437,231.178223781975),(-643285.881669843,-1062523.27945151,231.640003277694)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | vozovka/chodník | 0 | 5.27 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.6.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 26.8736 | řezová metoda | 0.23
vozovka_chodník-obrusná vrstva | 1.04663 | 1 | no | ((-643290.978613327,-1062532.19344864,231.45822050428),(-643285.860834982,-1062528.80256946,231.600000000093)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | vozovka/chodník | 0 | 5.27 | obrusná vrstva | 574A05 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.6.4 | ACO 16 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00598301 | řezová metoda | 0.06
vozovka_chodník-horní podkladní vrstva | 2.17386 | 1 | no | ((-643290.978613327,-1062532.19344864,231.40822050428),(-643285.817931961,-1062528.80256946,231.540000000093)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | vozovka/chodník | 0 | 5.27 | horní podkladní vrstva | 56360 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.6.4 | Recyklovaný materiál | TP 210 | P2 | 128;128;128 | 0.0343867 | řezová metoda | 0.05
vozovka_chodník-spodní podkladní vrstva | 7.91636 | 1 | no | ((-643290.978613327,-1062532.19344864,231.17822050428),(-643285.676351991,-1062528.80256946,231.490000000093)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | vozovka/chodník | 0 | 5.27 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.6.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 0.497323 | řezová metoda | 0.23
vozovka_chodník-obrusná vrstva | 0.88774 | 1 | no | ((-643302.67987415,-1062528.50867403,231.480138390229),(-643301.452970086,-1062523.29775618,231.569998317838)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | vozovka/chodník | 0 | 0 | obrusná vrstva | 574A05 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.6.4 | ACO 16 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00507476 | řezová metoda | 0.06
vozovka_chodník-horní podkladní vrstva | 1.85677 | 1 | no | ((-643302.770203164,-1062528.50867403,231.430138390229),(-643301.452970086,-1062523.29775618,231.509998317838)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | vozovka/chodník | 0 | 0 | horní podkladní vrstva | 56360 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.6.4 | Recyklovaný materiál | TP 210 | P2 | 128;128;128 | 0.0293341 | řezová metoda | 0.05
vozovka_chodník-spodní podkladní vrstva | 6.90761 | 1 | no | ((-643303.06828891,-1062528.50867403,231.200138390229),(-643301.452970086,-1062523.29775618,231.459998317838)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | vozovka/chodník | 0 | 0 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.6.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 0.431656 | řezová metoda | 0.23
vozovka_chodník-krytová vrstva nezpevněných vozovek | 3085.99 | 1 | no | ((-643287.169133716,-1062738.24590475,231.318220504271),(-642849.192711372,-1062532.18948878,232.832752453775)) | 36 | vozovka_chodník-krytová vrstva nezpevněných vozovek | Barva_36 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | vozovka/chodník | 5.26 | 487 | krytová vrstva nezpevněných vozovek | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.6.4 | MZK | ČSN 73 6126-1 | P2 | 125;75;0 | 289.082 | řezová metoda | 0.2
vozovka_chodník-spodní podkladní vrstva | 3104.02 | 1 | no | ((-643287.169133716,-1062738.24590475,231.118220504271),(-642849.192711372,-1062532.18948878,232.632752453775)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | vozovka/chodník | 5.26 | 487 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.6.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 316.082 | řezová metoda | 0.2
odvodnění-trativod | 890.689 | 1 | no | ((-643183.346779094,-1062736.03362319,231.069628658923),(-642849.192711372,-1062580.86771394,232.360752453775)) | 40 | odvodnění-trativod | Barva_40 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | odvodnění | 0.119 | 0.487 | trativod | 45152 | I1+S2+E1+Z1+M1+F1 |  |  |  |  | P100 | 255;165;0 | CZ_S2 - Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: vsakovací rýha; Stavební výrobek: kamenivo fr. 32/63 mm; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.1.6.4; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 368
vozovka_chodník-krytová vrstva nezpevněných vozovek | 88.6666 | 1 | no | ((-642966.933241528,-1062738.43498864,232.424867034071),(-642850.355822977,-1062686.54993729,232.832752453775)) | 36 | vozovka_chodník-krytová vrstva nezpevněných vozovek | Barva_36 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | vozovka/chodník | 359.67 | 487 | krytová vrstva nezpevněných vozovek | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.6.4 | MZK | ČSN 73 6126-1 | P2 | 125;75;0 | 2.61468 | řezová metoda | 0.2
vozovka_chodník-spodní podkladní vrstva | 166.609 | 1 | no | ((-642967.064098799,-1062738.71625094,232.21723882894),(-642850.355822977,-1062686.54993729,232.632752453775)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | vozovka/chodník | 359.67 | 487 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.6.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 10.3939 | řezová metoda | 0.2
vozovka_chodník-krytová vrstva nezpevněných vozovek | 199.371 | 1 | no | ((-642850.161971043,-1062754.58924571,232.503446298443),(-642837.267222584,-1062735.4805528,232.930846925817)) | 36 | vozovka_chodník-krytová vrstva nezpevněných vozovek | Barva_36 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | vozovka/chodník | 487 | 510 | krytová vrstva nezpevněných vozovek | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.6.4 | MZK | ČSN 73 6126-1 | P2 | 125;75;0 | 18.9423 | řezová metoda | 0.2
vozovka_chodník-spodní podkladní vrstva | 199.859 | 1 | no | ((-642850.161971043,-1062754.58924571,232.168446298441),(-642837.267222584,-1062735.4805528,232.730846925817)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | vozovka/chodník | 487 | 510 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.6.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 19.3217 | řezová metoda | 0.2
vozovka_chodník-krytová vrstva nezpevněných vozovek | 27.2569 | 1 | no | ((-642860.498042232,-1062747.45904356,232.595000000056),(-642847.48064447,-1062737.78501276,232.863290295008)) | 36 | vozovka_chodník-krytová vrstva nezpevněných vozovek | Barva_36 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | vozovka/chodník | 481.04 | 492.86 | krytová vrstva nezpevněných vozovek | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.6.4 | MZK | ČSN 73 6126-1 | P2 | 125;75;0 | 1.93175 | řezová metoda | 0.2
vozovka_chodník-spodní podkladní vrstva | 27.5593 | 1 | no | ((-642860.498042232,-1062747.45904356,232.395000000056),(-642847.48064447,-1062737.78501276,232.663290295008)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | vozovka/chodník | 481.04 | 492.86 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.6.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 2.00496 | řezová metoda | 0.2
vozovka_chodník-krytová vrstva nezpevněných vozovek | 12.9201 | 1 | no | ((-642860.552606196,-1062746.97705695,232.589871794928),(-642847.980431444,-1062738.24590475,232.848290295008)) | 36 | vozovka_chodník-krytová vrstva nezpevněných vozovek | Barva_36 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | vozovka/chodník | 480.91 | 491.97 | krytová vrstva nezpevněných vozovek | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.6.4 | MZK | ČSN 73 6126-1 | P2 | 125;75;0 | 0.380121 | řezová metoda | 0.2
vozovka_chodník-spodní podkladní vrstva | 23.854 | 1 | no | ((-642860.633770092,-1062746.97705695,232.3822435898),(-642847.980431444,-1062738.24590475,232.648290295008)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | vozovka/chodník | 480.72 | 491.97 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.6.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 1.48282 | řezová metoda | 0.2
vozovka_chodník-krytová vrstva nezpevněných vozovek | 29.9961 | 1 | no | ((-642859.168045618,-1062754.70289544,232.474999999944),(-642841.649434671,-1062748.50803451,232.859260229393)) | 36 | vozovka_chodník-krytová vrstva nezpevněných vozovek | Barva_36 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | vozovka/chodník | 484.13 | 510 | krytová vrstva nezpevněných vozovek | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.6.4 | MZK | ČSN 73 6126-1 | P2 | 125;75;0 | 2.12715 | řezová metoda | 0.2
vozovka_chodník-spodní podkladní vrstva | 30.324 | 1 | no | ((-642859.168045618,-1062754.70289544,232.274999999944),(-642841.649434671,-1062748.50803451,232.659260229393)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | vozovka/chodník | 484.13 | 510 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.6.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 2.20743 | řezová metoda | 0.2
vozovka_chodník-krytová vrstva nezpevněných vozovek | 14.4719 | 1 | no | ((-642859.035045956,-1062754.74952097,232.469871794816),(-642842.136347125,-1062749.00802638,232.844260229393)) | 36 | vozovka_chodník-krytová vrstva nezpevněných vozovek | Barva_36 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | vozovka/chodník | 484.44 | 510 | krytová vrstva nezpevněných vozovek | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.6.4 | MZK | ČSN 73 6126-1 | P2 | 125;75;0 | 0.425825 | řezová metoda | 0.2
vozovka_chodník-spodní podkladní vrstva | 26.9436 | 1 | no | ((-642859.035045956,-1062754.81887645,232.262243589688),(-642842.136347125,-1062749.00802638,232.644260229393)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | vozovka/chodník | 484.44 | 510 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.6.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 1.67431 | řezová metoda | 0.2
vozovka_chodník-krytová vrstva nezpevněných vozovek | 27.6358 | 1 | no | ((-642847.351048247,-1062753.5663981,232.488446298449),(-642836.78031013,-1062736.25591603,232.772102709961)) | 36 | vozovka_chodník-krytová vrstva nezpevněných vozovek | Barva_36 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | vozovka/chodník | 489 | 510 | krytová vrstva nezpevněných vozovek | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.6.4 | MZK | ČSN 73 6126-1 | P2 | 125;75;0 | 1.90421 | řezová metoda | 0.2
vozovka_chodník-spodní podkladní vrstva | 27.9181 | 1 | no | ((-642847.351048247,-1062753.5663981,232.288446298449),(-642836.78031013,-1062736.25591603,232.572102709961)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | vozovka/chodník | 489 | 510 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.6.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 1.97344 | řezová metoda | 0.2
vozovka_chodník-krytová vrstva nezpevněných vozovek | 14.9665 | 1 | no | ((-642847.348852227,-1062753.45274836,232.48331809332),(-642836.580551175,-1062736.07184213,232.757102709954)) | 36 | vozovka_chodník-krytová vrstva nezpevněných vozovek | Barva_36 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | vozovka/chodník | 489 | 510 | krytová vrstva nezpevněných vozovek | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.6.4 | MZK | ČSN 73 6126-1 | P2 | 125;75;0 | 0.439811 | řezová metoda | 0.2
vozovka_chodník-spodní podkladní vrstva | 28.3561 | 1 | no | ((-642847.348852227,-1062753.45274836,232.275689888192),(-642836.283409729,-1062735.79803222,232.557102709954)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | vozovka/chodník | 489 | 510 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.6.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 1.75832 | řezová metoda | 0.2
vozovka_chodník-krytová vrstva nezpevněných vozovek | 330.349 | 1 | no | ((-643285.873705889,-1062736.26038153,231.318267533472),(-642847.269409829,-1062532.01279062,232.749711597804)) | 36 | vozovka_chodník-krytová vrstva nezpevněných vozovek | Barva_36 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | vozovka/chodník | 5.27 | 489 | krytová vrstva nezpevněných vozovek | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.6.4 | MZK | ČSN 73 6126-1 | P2 | 125;75;0 | 9.67449 | řezová metoda | 0.2
vozovka_chodník-spodní podkladní vrstva | 682.157 | 1 | no | ((-643285.873705889,-1062736.26038153,231.118267533472),(-642847.146952201,-1062531.74180358,232.549711597804)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | vozovka/chodník | 5.27 | 489 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.6.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 49.2097 | řezová metoda | 0.2
trubní vedení-potrubí | 1.00204 | 2 | no | ((-643303.659182271,-1062525.47315015,230.956038483063),(-643302.443266086,-1062523.13039628,231.091249234417)) | 4 | trubní vedení-potrubí | Barva_4 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | trubní vedení | 0 | 0 | potrubí | 87433 | I1+S1+E1+Z1+M1+F1 | nerelevantni | D.1.6.2 | PVC | SN8 DN125 | P10 | 0;255;255 | CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 2.5
založení-patka _ pás | 84.7517 | 2 | no | ((-643014.658786025,-1062686.73066037,231.977219523163),(-642966.845168967,-1062663.92191262,232.629995485488)) | 6 | založení-patka _ pás | Barva_6 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | založení | 306.86 | 359.67 | patka / pás | 272313 | I1+S1;4+E1+Z1+M3+F1 | ZB 20 | CDE 1.7.3.2 PDF - D.1.6.2 | beton | 0 | P10 | 255;0;255 | 6.33838 | řezová metoda | CZ_S4 - Specifikace: nerelevantni; Beton: C16/20 XC2; Typ betonářské vyztuže: nerelevantni; Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.1.6.2; Návrhová životnost: 25 let
odvodnění-trativod | 268.522 | 1 | no | ((-643286.139461203,-1062580.12716254,230.518220504271),(-643185.802041939,-1062532.18948878,231.698267144917)) | 40 | odvodnění-trativod | Barva_40 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | odvodnění | 5.26 | 116 | trativod | 45152 | I1+S2+E1+Z1+M1+F1 |  |  |  |  | P100 | 255;165;0 | CZ_S2 - Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: vsakovací rýha; Stavební výrobek: kamenivo fr. 32/63 mm; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.1.6.4; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 110.74
trubní vedení-podsyp | 2.91674 | 2 | no | ((-643303.783993255,-1062525.53320933,230.806040358083),(-643302.317862618,-1062523.06911018,230.968750765638)) | 2 | trubní vedení-podsyp | Barva_2 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | trubní vedení | 0 | 0 | podsyp | 45157 | I1+S1+E1+Z1+M3+F1 | nerelevantni | D.1.6.2 | ŠP | nerelevantni | P50 | 255;255;0 | 0.152549 | řezová metoda
trubní vedení-obsyp | 3.79948 | 2 | no | ((-643303.784319394,-1062525.5338847,230.956040358081),(-643302.317862618,-1062523.06911018,231.268748890671)) | 40 | trubní vedení-obsyp | Barva_40 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | trubní vedení | 0 | 0 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 |  |  |  |  | P50 | 255;165;0 | 0.305099 | řezová metoda | 0.2 | CZ_S2 - Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: ŠP; Stavební výrobek: nerelevantni; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.1.6.2
zemní práce-výkop rýhy | 6.2373 | 2 | no | ((-643303.784893711,-1062525.53507399,230.806040358557),(-643302.317862618,-1062523.06911018,231.532889527057)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | zemní práce | 0 | 0 | výkop rýhy | 13273 | I1+S3+E1+Z1+M3+F1 |  |  |  |  | P100 | 125;75;0 | 0.726279 | řezová metoda | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
zemní práce-zásyp rýhy | 3.58847 | 2 | no | ((-643303.78421181,-1062525.53487497,231.256038987194),(-643302.317832995,-1062523.07026188,231.532891906099)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | zemní práce | 0 | 0 | zásyp rýhy | 17411 | I1+S3+E1+Z1+M3+F1 |  |  |  |  | P100 | 0;128;0 | 0.268633 | řezová metoda | CZ_S3 - Klasifikace zemin / hornin: 0; Třída těžitelnosti: 1; Další specifikace: 0
odvodnění-žlaby štěrbinové | 22.1163 | 1 | no | ((-643303.058461739,-1062529.42945441,231.266712449733),(-643289.197933363,-1062522.69231014,231.60363171529)) | 6 | odvodnění-žlaby štěrbinové | Barva_6 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | odvodnění | 0 | 1 | žlaby štěrbinové | 935161 | I1+S2+E1+Z1+M1+F1 |  |  |  |  | P2 | 255;0;255 | CZ_S2 - Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: odvodňovací žlab; Stavební výrobek: štěrbinový žlab z bet. dílců; Specifikace: D400, š. do 250 mm, v. do 300 mm; Podrobná specifikace: přerušovaná štěrbina, bez vnitřního spádu, vč. vpusti a čístího kusu; Reference: D.1.6.4; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 15.24
odvodnění-podkladní beton | 28.545 | 1 | no | ((-643303.127106569,-1062529.57398084,231.116712449733),(-643289.129288527,-1062522.54778371,231.49363171529)) | 9 | odvodnění-podkladní beton | Barva_9 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | odvodnění | 0.01 | 1 | podkladní beton | 45131A | I1+S1+E1+Z1+M3+F1 | nerelevantni | D.1.6.2 | beton | C20/25nXF3 | P10 | 191;191;191 | 1.77089 | řezová metoda
propustky-podkladní vrstva | 22.7714 | 1 | no | ((-643303.127106569,-1062529.57398084,230.916712449733),(-643289.129288527,-1062522.54778371,231.19363171529)) | 2 | propustky-podkladní vrstva | Barva_2 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | propustky | 0.01 | 1 | podkladní vrstva | 45152 | I1+S1+E1+Z1+M3+F1 | nerelevantni | D.1.6.4 | ŠD fr. 0/32 | nerelevantni | P50 | 255;255;0 | 1.64592 | řezová metoda
zemní práce-výkop_odkop | 1072.81 | 1 | no | ((-643303.06828891,-1062736.26038153,231.118267533472),(-642847.146952201,-1062523.29775618,233.130585208209)) | 36 | zemní práce-výkop_odkop | Barva_36 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | zemní práce | 0 | 489 | výkop/odkop | 12373 | I1+S3+E1+Z1+M3+F1 |  |  |  |  | P100 | 125;75;0 | 146.333 | řezová metoda | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
zemní práce-výkop_odkop | 265.491 | 1 | no | ((-643302.652919771,-1062736.26038153,231.17822050428),(-642847.351048247,-1062523.27898116,233.036446724412)) | 36 | zemní práce-výkop_odkop | Barva_36 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | zemní práce | 0 | 489 | výkop/odkop | 12373 | I1+S3+E1+Z1+M3+F1 |  |  |  |  | P100 | 125;75;0 | 42.3408 | řezová metoda | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
vozovka_chodník-krytová vrstva nezpevněných vozovek | 209.733 | 1 | no | ((-643287.257139914,-1062664.10714473,231.403092299143),(-643014.572860669,-1062534.8993592,232.577218515454)) | 36 | vozovka_chodník-krytová vrstva nezpevněných vozovek | Barva_36 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | vozovka/chodník | 5.26 | 306.86 | krytová vrstva nezpevněných vozovek | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.6.4 | MZK | ČSN 73 6126-1 | P2 | 125;75;0 | 6.18643 | řezová metoda | 0.2
vozovka_chodník-spodní podkladní vrstva | 393.96 | 1 | no | ((-643287.388049133,-1062664.3826775,231.195464094015),(-643014.572860669,-1062534.8993592,232.377218515454)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | vozovka/chodník | 5.26 | 306.86 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.6.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 24.591 | řezová metoda | 0.2
dopravní značení-svislé dopravní značení | 0.587153 | 2 | yes | ((-643284.423965279,-1062536.35642251,231.6),(-643284.345753869,-1062536.2782111,233.95052612008)) | 7 | dopravní značení-svislé dopravní značení | Barva_7 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | dopravní značení | 8.42 | 8.42 | svislé dopravní značení | 914924 | I1+S2+E1+Z1+M4+F1 |  |  |  |  | P10 | 255;255;255 | CZ_S2 - Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: sloupek; Specifikace: velikost zmenšená, RA1; Podrobná specifikace: TP 65; Reference: D.1.6.4; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
trasa-průjezdní a průchozí prostor | 0.06 | 4 | yes | ((-643290.693234702,-1062530.08561754,231.6),(-643290.593234702,-1062529.98561754,231.7)) | 9 | trasa-průjezdní a průchozí prostor | Barva_9 |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  | P2 | 191;191;191 | CZ_I3 - Fáze projektu: PDPS; Název (trasy): Účelová komunikace; Staničení od: 0.02; Staničení do: 0.11; Označení elementu: průjezdní a průchozí prostor; Označení průjezdného profilu: nerelevantni; Klasifikační systém: nerelevantni; Označení položky: nerelevantni; Označení šablony vlastností: I3+E1+Z1+F1
dopravní značení-svislé dopravní značení | 0.408407 | 2 | yes | ((-643284.55204017,-1062536.53087782,233.700374123147),(-643284.338998067,-1062536.06237501,234.200474071394)) | 7 | dopravní značení-svislé dopravní značení | Barva_7 | SO 106 | nerelevantni | PDPS | Účelová komunikace pro zajištění obslužnosti | OTSKP | dopravní značení | 8.31 | 8.32 | svislé dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 |  |  |  |  | P10 | 255;255;255 | CZ_S2 - Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: B32; Specifikace: velikost zmenšená, RA1; Podrobná specifikace: TP 65; Reference: D.1.6.4; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu

# IfcGeographicElement (7)
In: UnknownName
PredefinedType: TERRAIN
Properties - HasSnapshot: no; IsSnapshotOutOfDate: no; IsVolumeSurface: no; Lock: no; DisplayName: Povrch TIN; IsReferenceObject: no; IsReferenceStale: no; IsReferenceSubObject: no; IsReferenceValid: no; ShowToolTip: yes; CloneMeForDragging: no; ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: no; IsModifiedGraphics: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no
Miscellaneous - IsHighlighting: no; NeedsPromoting: no; SupportsBaseCurveCommands: no; SupportsProfileCommands: no; SwappingReferences: no; TypeIcon: (Icon)
General - LayerKey: AeccSurfaceTin; Linetype: ByLayer; LinetypeScale: 1; Visible: yes
Geometry - Closed: no; IsPeriodic: no; IsPlanar: yes
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
CZ_I1 - Označení stavebního objektu: SO 106; Označení podobjektu: nerelevantni; Označení části objektu: nerelevantni; Fáze projektu: PDPS; Název stavebního objektu: Účelová komunikace pro zajištění obslužnosti; Klasifikační systém: OTSKP
CZ_E1 - Datum zahájení prací: 01.05.2025; Datum dokončení: 30.06.2027; Doba trvání: 790; Datum uvedení do provozu: 01.07.2027; Stavební postup / etapa výstavby: nerelevantni
CZ_F1 - Fáze: trvalý stav
Name | AutoRebuild = IsUsed | IsOutOfDate | FingerPrint | Name | StyleName | Bounds | ColorIndex | Layer | PlotStyleName | Staničení od | Staničení do | Označení elementu | Skupina elementů | Označení položky | Označení šablony vlastností | Materiál | specifikace | podrobná specifikace | CZ_S1, Reference | Textura / barva | Skupina přesnosti | Plocha | Způsob stanovení plochy
zemní práce-pláň-3 | no | yes | -29552929 | zemní práce-pláň-3 | plan | ((-643402.652919771,-1062836.26038153,231.17822050428),(-642747.351048247,-1062423.27898116,232.409711597804)) | 96 | zemní práce-pláň | Barva_96 | 387.59 | 489 | pláň | zemní práce | 18110 | I1+S1+E1+Z1+M2+F1 | nerelevantni | ČSN 73 6133 | nerelevantni | D.1.6.4 | 0;128;0 | P10 | 115.877 | 3D plocha TIN povrchu | Description: Popis; Properties - Description: Popis
zemní práce-pláň-1 | yes | no | 1941099619 | zemní práce-pláň-1 | plan | ((-643387.173534026,-1062854.81887645,231.118220504271),(-642736.283409729,-1062432.18948878,232.530846925817)) | 96 | zemní práce-pláň | Barva_96 | 7.5 | 510 | pláň | zemní práce | 18110 | I1+S1+E1+Z1+M2+F1 | nerelevantni | ČSN 73 6133 | nerelevantni | D.1.6.4 | 0;128;0 | P10 | 1706.37 | 3D plocha TIN povrchu
vozovka_chodník-geosyntetikum-1 | yes | no | 855237968 | vozovka_chodník-geosyntetikum-1 | geotextilie | ((-643386.139461203,-1062854.58924571,230.518220504271),(-642737.267222584,-1062432.18948878,232.448290295008)) | 216 | vozovka_chodník-geosyntetikum | Barva_216 | 5.26 | 487 | geosyntetikum | vozovka/chodník | 214611 | I1+S1+E1+Z1+M2+F1 | separační geotextilie | TP 97 | typ S1, filtrace nevýznamná | D.1.6.4 | 127;0;127 | P2 | 865.613 | 3D plocha TIN povrchu
vozovka_chodník-geosyntetikum-2 | yes | no | -1076513344 | vozovka_chodník-geosyntetikum-2 | geotextilie | ((-643386.139461203,-1062854.58924571,231.118220504271),(-642737.267222584,-1062432.18948878,232.448290295008)) | 216 | vozovka_chodník-geosyntetikum | Barva_216 | 17.5 | 480 | geosyntetikum | vozovka/chodník | 214611 | I1+S1+E1+Z1+M2+F1 | separační geotextilie | TP 97 | typ S1, filtrace nevýznamná | D.1.6.4 | 127;0;127 | P2 | 287.213 | 3D plocha TIN povrchu
zemní práce-pláň-2 | yes | no | 1512805463 | zemní práce-pláň-2 | plan | ((-643403.06828891,-1062836.26038153,231.118267533472),(-642747.146952201,-1062423.29775618,232.349711597804)) | 96 | zemní práce-pláň | Barva_96 | 7.5 | 488.62 | pláň | zemní práce | 18110 | I1+S1+E1+Z1+M2+F1 | nerelevantni | ČSN 73 6133 | nerelevantni | D.1.6.4 | 0;128;0 | P10 | 265.359 | 3D plocha TIN povrchu
ostatní-oplocení-1 | no | yes | 327576147 | ostatní-oplocení-1 | postřiky | ((-643401.497840047,-1062636.11836738,231.646195668203),(-643189.34,-1062432.33567341,233.55)) | 4 | ostatní-oplocení | Barva_4 | 0 | 0 | oplocení | ostatní | 767912 | I1+S2+E1+Z1+M1;5+F1 |  |  |  |  | 0;255;255 | P10 | Description: Popis; Properties - Description: Popis; CZ_S2 - Typ stavebního výrobku: Oplocení; Stavební výrobek: Drátěné oplocení se sloupky vč. bran; Specifikace: kovové; Podrobná specifikace: výška do 1,8 m; Reference: D.1.6.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M1 - Délka: 14; Způsob stanovení délky: Délka 3D křivky; CZ_M5 - Hmotnost: 1; Způsob stanovení hmotnosti: data ze statického posouzení
ostatní-oplocení-2 | no | yes | 143194065 | ostatní-oplocení-2 | postřiky | ((-643114.619714255,-1062786.64933221,232.277219187003),(-642866.888105452,-1062564.01240613,234.429995249957)) | 4 | ostatní-oplocení | Barva_4 | 322.5 | 359.67 | oplocení | ostatní | 767912 | I1+S2+E1+Z1+M1;5+F1 |  |  |  |  | 0;255;255 | P10 | Description: Popis; Properties - Description: Popis; CZ_S2 - Typ stavebního výrobku: Oplocení; Stavební výrobek: Drátěné oplocení se sloupky vč. bran; Specifikace: kovové; Podrobná specifikace: výška do 1,8 m; Reference: D.1.6.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M1 - Délka: 37.17; Způsob stanovení délky: Délka 3D křivky; CZ_M5 - Hmotnost: 1; Způsob stanovení hmotnosti: data ze statického posouzení
