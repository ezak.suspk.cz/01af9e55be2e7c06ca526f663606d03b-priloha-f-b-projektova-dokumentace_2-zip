Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [Ifc4X3NotAssigned]
File name: D:\_Projekty\2017_07 - SÚS Obchvat Dašic\4_PDPS\BIM\IFC\SO 107.ifc
Time: 2025-05-26T09:26:40
Author: Michal Švarc
Organization: DESKTOP-47J51D1
Written by: GeometryGymIFCcore v24.8.23.0 by Geometry Gym Pty Ltd built 2024-08-23T03:53:20
Made in: Civil 3D 2024 IfcInfra Plugin v13.6.170.0
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcProject, SO 107
Summary - Title: CAD Studio Silniční šablona; Author: Martin Folber, Ondřej Vojtěchovský, Jakub Kareš; HyperlinkBase: www.cadstudio.cz
Custom_Properties - Investor: Správa a údržba silnic Pardubického kraje, Doubravice 98, 533 53 Pardubice; Stupeň PD: DÚSP; Příloha č.: 2.; Část: D; Datum PD: 02.2022; Místo: Pardubický kraj/obec

# IfcBuiltElement (65)
In: UnknownName
Properties - ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: no; IsModifiedGraphics: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no; IsNull: no; UsesGraphicsCache: yes; CloneMeForDragging: yes
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
General - Linetype: ByLayer; LinetypeScale: 1; Visible: yes
Geometry - IsPlanar: no
CZ_E1 - Datum zahájení prací: 01.05.2025; Datum dokončení: 30.06.2027; Doba trvání: 790; Datum uvedení do provozu: 01.07.2027; Stavební postup / etapa výstavby: nerelevantni
CZ_F1 - Fáze: trvalý stav
Name | Area | NumChanges | RecordHistory = ShowHistory | Bounds | ColorIndex | PlotStyleName | Layer | Označení stavebního objektu | Označení podobjektu = Označení části objektu | CZ_I1, Fáze projektu | Název stavebního objektu | Skupina elementů | CZ_I1, Klasifikační systém | CZ_I1, Staničení od | CZ_I1, Staničení do | CZ_I1, Označení elementu | CZ_I1, Označení položky | CZ_I1, Označení šablony vlastností | podrobná specifikace | CZ_S1, Reference | Materiál | specifikace | Textura / barva | Skupina přesnosti | Objem | Způsob stanovení objemu | Tloušťka
vozovka_chodník-horní podkladní vrstva | 402.208 | 2 | no | ((-642726.9716675,-1062709.20337471,232.125025918785),(-642680.725806523,-1062688.87598359,232.77327619297)) | 8 | Barva_8 | vozovka_chodník-horní podkladní vrstva | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | vozovka/chodník | OTSKP | 12 | 70 | horní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ŠDA | ČSN 73 6126-1 | 128;128;128 | P2 | 28.8653 | řezová metoda | 0.15
vozovka_chodník-spodní podkladní vrstva | 408.899 | 2 | no | ((-642726.9716675,-1062709.20337471,231.908775918783),(-642680.725806523,-1062688.87598359,232.62327619297)) | 8 | Barva_8 | vozovka_chodník-spodní podkladní vrstva | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | vozovka/chodník | OTSKP | 12 | 70 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ŠDB | nerelevantni | 128;128;128 | P2 | 40.2551 | řezová metoda | 0.2
vozovka_chodník-horní podkladní vrstva | 428.641 | 2 | no | ((-642727.308873202,-1062708.75245118,232.125025918785),(-642677.507240387,-1062685.46042986,232.77327619297)) | 8 | Barva_8 | vozovka_chodník-horní podkladní vrstva | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | vozovka/chodník | OTSKP | 12 | 70 | horní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ŠDA | ČSN 73 6126-1 | 128;128;128 | P2 | 30.6794 | řezová metoda | 0.15
vozovka_chodník-spodní podkladní vrstva | 436.313 | 2 | no | ((-642727.308873202,-1062708.75245118,231.908775918783),(-642677.507240387,-1062685.46042986,232.62327619297)) | 8 | Barva_8 | vozovka_chodník-spodní podkladní vrstva | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | vozovka/chodník | OTSKP | 12 | 70 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ŠDB | nerelevantni | 128;128;128 | P2 | 42.95 | řezová metoda | 0.2
vozovka_chodník-obrusná vrstva | 2.37082 | 2 | no | ((-642689.143195501,-1062721.79541227,232.189393939391),(-642683.443126658,-1062709.20337471,232.33)) | 8 | Barva_8 | vozovka_chodník-obrusná vrstva | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | vozovka/chodník | OTSKP | 0.25 | 12 | obrusná vrstva | 574A05 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ACO 16 50/70 | nerelevantni | 128;128;128 | P2 | 0.013595 | řezová metoda | 0.06
vozovka_chodník-horní podkladní vrstva | 4.36841 | 2 | no | ((-642689.153653,-1062721.79541227,232.137888888886),(-642683.443126658,-1062709.20337471,232.27)) | 8 | Barva_8 | vozovka_chodník-horní podkladní vrstva | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | vozovka/chodník | OTSKP | 0.25 | 12 | horní podkladní vrstva | 56360 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | Recyklovaný materiál | TP 210 | 128;128;128 | P2 | 0.0692208 | řezová metoda | 0.05
zemní práce-rozprostření ornice (ohumusovani) | 35.0346 | 2 | no | ((-642689.536147017,-1062721.30588093,231.398008764535),(-642683.943126425,-1062711.73760024,232.29)) | 73 | Barva_73 | zemní práce-rozprostření ornice (ohumusovani) | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | zemní práce | OTSKP | 0.74 | 9.51 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ornice | nerelevantni | 165;207;99 | P100 | 1.61553 | řezová metoda | 0.1
zemní práce-rozprostření ornice (ohumusovani) | 14.4537 | 2 | no | ((-642689.576542834,-1062718.90954121,231.398008764535),(-642685.194162753,-1062711.91005736,232.010864152185)) | 73 | Barva_73 | zemní práce-rozprostření ornice (ohumusovani) | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | zemní práce | OTSKP | 3.11 | 9.52 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ornice | nerelevantni | 165;207;99 | P100 | 0.620225 | řezová metoda | 0.1
vozovka_chodník-spodní podkladní vrstva | 31.1825 | 2 | no | ((-642689.331049793,-1062721.79541227,231.892733226856),(-642683.443126658,-1062709.20337471,232.22)) | 8 | Barva_8 | vozovka_chodník-spodní podkladní vrstva | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | vozovka/chodník | OTSKP | 0.25 | 12 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ŠDB | nerelevantni | 128;128;128 | P2 | 1.97442 | řezová metoda | 0.23
vozovka_chodník-zpevnění krajnic | 17.138 | 2 | no | ((-642689.208467141,-1062721.79541227,232.109680510365),(-642683.443126658,-1062709.20337471,232.33)) | 8 | Barva_8 | vozovka_chodník-zpevnění krajnic | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | vozovka/chodník | OTSKP | 0.25 | 12 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1 | nerelevantni | D.1.7.4 | Recyklovaný materiál | nerelevantni | 128;128;128 | P2 | 0.658801 | řezová metoda
vozovka_chodník-obrusná vrstva | 2.37148 | 2 | no | ((-642677.507240387,-1062718.99097437,232.146612506932),(-642669.039762897,-1062708.29732324,232.28)) | 8 | Barva_8 | vozovka_chodník-obrusná vrstva | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | vozovka/chodník | OTSKP | 0.25 | 12 | obrusná vrstva | 574A05 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ACO 16 50/70 | nerelevantni | 128;128;128 | P2 | 0.0135882 | řezová metoda | 0.06
vozovka_chodník-horní podkladní vrstva | 4.36775 | 2 | no | ((-642677.507240387,-1062718.99097437,232.095107456427),(-642669.039762897,-1062708.28688227,232.22)) | 8 | Barva_8 | vozovka_chodník-horní podkladní vrstva | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | vozovka/chodník | OTSKP | 0.25 | 12 | horní podkladní vrstva | 56360 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | Recyklovaný materiál | TP 210 | 128;128;128 | P2 | 0.0691886 | řezová metoda | 0.05
zemní práce-rozprostření ornice (ohumusovani) | 36.3757 | 2 | no | ((-642676.651068906,-1062718.50877959,231.295123367443),(-642669.107052058,-1062710.62027124,232.213980638512)) | 73 | Barva_73 | zemní práce-rozprostření ornice (ohumusovani) | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | zemní práce | OTSKP | 0.74 | 9.4 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ornice | nerelevantni | 165;207;99 | P100 | 1.6856 | řezová metoda | 0.1
zemní práce-rozprostření ornice (ohumusovani) | 16.1841 | 2 | no | ((-642675.301960972,-1062716.69374787,231.295123367443),(-642669.66741445,-1062710.52923074,231.995792242823)) | 73 | Barva_73 | zemní práce-rozprostření ornice (ohumusovani) | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | zemní práce | OTSKP | 2.72 | 9.38 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ornice | nerelevantni | 165;207;99 | P100 | 0.704616 | řezová metoda | 0.1
vozovka_chodník-spodní podkladní vrstva | 29.5507 | 2 | no | ((-642677.507240387,-1062718.99097437,231.850049660529),(-642669.039762897,-1062708.18636853,232.17)) | 8 | Barva_8 | vozovka_chodník-spodní podkladní vrstva | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | vozovka/chodník | OTSKP | 0.25 | 12 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ŠDB | nerelevantni | 128;128;128 | P2 | 1.89033 | řezová metoda | 0.23
vozovka_chodník-zpevnění krajnic | 17.1341 | 2 | no | ((-642677.507240387,-1062718.99097437,232.066899077907),(-642669.039762897,-1062708.2321548,232.28)) | 8 | Barva_8 | vozovka_chodník-zpevnění krajnic | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | vozovka/chodník | OTSKP | 0.25 | 12 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1 | nerelevantni | D.1.7.4 | Recyklovaný materiál | nerelevantni | 128;128;128 | P2 | 0.658617 | řezová metoda
vozovka_chodník-horní podkladní vrstva | 760.106 | 2 | no | ((-642759.006034235,-1062697.27206064,232.545925945608),(-642726.764336105,-1062673.09830974,233.004054693505)) | 8 | Barva_8 | vozovka_chodník-horní podkladní vrstva | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | vozovka/chodník | OTSKP | 70 | 93.85 | horní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ŠDA | ČSN 73 6126-1 | 128;128;128 | P2 | 55.9676 | řezová metoda | 0.15
vozovka_chodník-spodní podkladní vrstva | 764.714 | 2 | no | ((-642759.006034235,-1062697.27206064,232.345925945608),(-642726.764336105,-1062673.09830974,232.854054693506)) | 8 | Barva_8 | vozovka_chodník-spodní podkladní vrstva | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | vozovka/chodník | OTSKP | 70 | 93.85 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ŠDB | nerelevantni | 128;128;128 | P2 | 74.6235 | řezová metoda | 0.2
vozovka_chodník-obrusná vrstva | 228.397 | 2 | no | ((-642689.138984428,-1062722.04347178,232.147218567539),(-642669.005009574,-1062708.28890271,232.356275918795)) | 8 | Barva_8 | vozovka_chodník-obrusná vrstva | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | vozovka/chodník | OTSKP | 0 | 12.01 | obrusná vrstva | 574A05 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ACO 16 50/70 | nerelevantni | 128;128;128 | P2 | 6.74728 | řezová metoda | 0.06
vozovka_chodník-horní podkladní vrstva | 227.824 | 2 | no | ((-642689.138984428,-1062722.04347178,232.097218567539),(-642669.005009574,-1062708.28890271,232.296275918795)) | 8 | Barva_8 | vozovka_chodník-horní podkladní vrstva | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | vozovka/chodník | OTSKP | 0 | 12.01 | horní podkladní vrstva | 56360 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | Recyklovaný materiál | TP 210 | 128;128;128 | P2 | 5.62273 | řezová metoda | 0.05
vozovka_chodník-spodní podkladní vrstva | 238.148 | 2 | no | ((-642689.138984428,-1062722.04347178,231.867218567539),(-642669.005009574,-1062708.28890271,232.246275918795)) | 8 | Barva_8 | vozovka_chodník-spodní podkladní vrstva | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | vozovka/chodník | OTSKP | 0 | 12.01 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ŠDB | nerelevantni | 128;128;128 | P2 | 25.8646 | řezová metoda | 0.23
vozovka_chodník-horní podkladní vrstva | 22.6007 | 2 | no | ((-642727.320051317,-1062708.30152765,232.172461816221),(-642677.40566828,-1062685.36086074,232.695925945608)) | 8 | Barva_8 | vozovka_chodník-horní podkladní vrstva | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | vozovka/chodník | OTSKP | 12 | 70 | horní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ŠDA | ČSN 73 6126-1 | 128;128;128 | P2 | 0.331405 | řezová metoda | 0.15
vozovka_chodník-horní podkladní vrstva | 24.5887 | 2 | no | ((-642727.325640375,-1062708.30152765,232.121179764939),(-642677.354882227,-1062685.31107619,232.595925945608)) | 8 | Barva_8 | vozovka_chodník-horní podkladní vrstva | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | vozovka/chodník | OTSKP | 12 | 70 | horní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ŠDA | ČSN 73 6126-1 | 128;128;128 | P2 | 0.41456 | řezová metoda | 0.15
vozovka_chodník-spodní podkladní vrstva | 32.8926 | 2 | no | ((-642727.336539038,-1062708.30152765,232.118679764939),(-642677.255849423,-1062685.2139963,232.545925945608)) | 8 | Barva_8 | vozovka_chodník-spodní podkladní vrstva | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | vozovka/chodník | OTSKP | 0.012 | 0.07 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ŠDB | nerelevantni | 128;128;128 | P2 | 3.2 | řezová metoda | 0.2
zemní práce-rozprostření ornice (ohumusovani) | 125.33 | 2 | no | ((-642727.436932488,-1062708.2321548,231.335025918785),(-642675.702960629,-1062684.31974121,232.655925945608)) | 73 | Barva_73 | zemní práce-rozprostření ornice (ohumusovani) | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | zemní práce | OTSKP | 12 | 70 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ornice | nerelevantni | 165;207;99 | P100 | 5.50656 | řezová metoda | 0.1
zemní práce-rozprostření ornice (ohumusovani) | 117.8 | 2 | no | ((-642727.521764241,-1062708.0487467,231.335025918785),(-642674.806224117,-1062683.60816769,232.724838251483)) | 73 | Barva_73 | zemní práce-rozprostření ornice (ohumusovani) | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | zemní práce | OTSKP | 12 | 70 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ornice | nerelevantni | 165;207;99 | P100 | 5.11353 | řezová metoda | 0.1
vozovka_chodník-spodní podkladní vrstva | 130.024 | 2 | no | ((-642727.401075604,-1062708.30152765,231.882073861877),(-642676.62578053,-1062684.62933461,232.545925945608)) | 8 | Barva_8 | vozovka_chodník-spodní podkladní vrstva | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | vozovka/chodník | OTSKP | 12 | 70 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ŠDB | nerelevantni | 128;128;128 | P2 | 8.50694 | řezová metoda | 0.2
zemní práce-zemní krajnice a dosypávky | 71.3476 | 2 | no | ((-642727.375386574,-1062708.28639841,232.039968382),(-642676.884158281,-1062684.85815975,232.586883022095)) | 8 | Barva_8 | zemní práce-zemní krajnice a dosypávky | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | zemní práce | OTSKP | 12 | 70 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1 | nerelevantni | D.1.7.4 | nenamrzavý materiál | nerelevantni | 128;128;128 | P100 | 1.90747 | řezová metoda
vozovka_chodník-zpevnění krajnic | 74.8345 | 2 | no | ((-642727.363366515,-1062708.30152765,232.134706429153),(-642677.012076366,-1062684.97503043,232.695925945608)) | 8 | Barva_8 | vozovka_chodník-zpevnění krajnic | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | vozovka/chodník | OTSKP | 12 | 70 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1 | nerelevantni | D.1.7.4 | Recyklovaný materiál | nerelevantni | 128;128;128 | P2 | 2.90471 | řezová metoda
vozovka_chodník-horní podkladní vrstva | 17.8425 | 2 | no | ((-642726.764336105,-1062709.21760504,232.172461816221),(-642683.944372659,-1062692.21581009,232.725717285492)) | 8 | Barva_8 | vozovka_chodník-horní podkladní vrstva | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | vozovka/chodník | OTSKP | 12 | 70 | horní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ŠDA | ČSN 73 6126-1 | 128;128;128 | P2 | 0.262083 | řezová metoda | 0.15
vozovka_chodník-horní podkladní vrstva | 19.3958 | 2 | no | ((-642726.764336105,-1062709.22472021,232.121179764939),(-642683.944372659,-1062692.21581009,232.625717285492)) | 8 | Barva_8 | vozovka_chodník-horní podkladní vrstva | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | vozovka/chodník | OTSKP | 12 | 70 | horní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ŠDA | ČSN 73 6126-1 | 128;128;128 | P2 | 0.3273 | řezová metoda | 0.15
vozovka_chodník-spodní podkladní vrstva | 25.8827 | 2 | no | ((-642726.764336105,-1062709.23859478,232.118679764939),(-642683.944372659,-1062692.21581009,232.575717285492)) | 8 | Barva_8 | vozovka_chodník-spodní podkladní vrstva | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | vozovka/chodník | OTSKP | 0.012 | 0.07 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ŠDB | nerelevantni | 128;128;128 | P2 | 2.6 | řezová metoda | 0.2
zemní práce-rozprostření ornice (ohumusovani) | 95.6231 | 2 | no | ((-642726.709842791,-1062709.44663996,231.395025918785),(-642684.43953668,-1062692.71429365,232.685717285492)) | 73 | Barva_73 | zemní práce-rozprostření ornice (ohumusovani) | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | zemní práce | OTSKP | 12 | 70 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ornice | nerelevantni | 165;207;99 | P100 | 4.20792 | řezová metoda | 0.1
zemní práce-rozprostření ornice (ohumusovani) | 77.3165 | 2 | no | ((-642726.636276818,-1062709.62444817,231.395025918785),(-642685.680732022,-1062693.38724645,232.607479359315)) | 73 | Barva_73 | zemní práce-rozprostření ornice (ohumusovani) | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | zemní práce | OTSKP | 12 | 70 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ornice | nerelevantni | 165;207;99 | P100 | 3.30828 | řezová metoda | 0.1
vozovka_chodník-spodní podkladní vrstva | 101.257 | 2 | no | ((-642726.764336105,-1062709.32848031,231.881725222614),(-642683.944372659,-1062692.21581009,232.575717285492)) | 8 | Barva_8 | vozovka_chodník-spodní podkladní vrstva | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | vozovka/chodník | OTSKP | 12 | 70 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ŠDB | nerelevantni | 128;128;128 | P2 | 6.64249 | řezová metoda | 0.2
zemní práce-zemní krajnice a dosypávky | 55.5782 | 2 | no | ((-642726.752451884,-1062709.29132829,232.039825824948),(-642684.052360924,-1062692.3245223,232.616674361979)) | 8 | Barva_8 | zemní práce-zemní krajnice a dosypávky | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | zemní práce | OTSKP | 12 | 70 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1 | nerelevantni | D.1.7.4 | nenamrzavý materiál | nerelevantni | 128;128;128 | P100 | 1.48667 | řezová metoda
vozovka_chodník-zpevnění krajnic | 58.4407 | 2 | no | ((-642726.764336105,-1062709.27274756,232.134706429153),(-642683.944372659,-1062692.21581009,232.725717285492)) | 8 | Barva_8 | vozovka_chodník-zpevnění krajnic | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | vozovka/chodník | OTSKP | 12 | 70 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1 | nerelevantni | D.1.7.4 | Recyklovaný materiál | nerelevantni | 128;128;128 | P2 | 2.26729 | řezová metoda
vozovka_chodník-horní podkladní vrstva | 5.10896 | 2 | no | ((-642758.90387417,-1062697.30216845,232.669393939394),(-642726.798997247,-1062693.61057159,232.795044511)) | 8 | Barva_8 | vozovka_chodník-horní podkladní vrstva | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | vozovka/chodník | OTSKP | 70.04 | 94.23 | horní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ŠDA | ČSN 73 6126-1 | 128;128;128 | P2 | 0.0293723 | řezová metoda | 0.15
vozovka_chodník-horní podkladní vrstva | 9.4554 | 2 | no | ((-642758.90387417,-1062697.3769362,232.617888888889),(-642726.790469241,-1062693.61057159,232.735044511)) | 8 | Barva_8 | vozovka_chodník-horní podkladní vrstva | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | vozovka/chodník | OTSKP | 70.04 | 94.23 | horní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ŠDA | ČSN 73 6126-1 | 128;128;128 | P2 | 0.150125 | řezová metoda | 0.15
vozovka_chodník-spodní podkladní vrstva | 13.2855 | 2 | no | ((-642758.90387417,-1062697.47629199,232.615888888889),(-642726.779136724,-1062693.61057159,232.685044511)) | 8 | Barva_8 | vozovka_chodník-spodní podkladní vrstva | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | vozovka/chodník | OTSKP | 0.07 | 0.0954 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ŠDB | nerelevantni | 128;128;128 | P2 | 1.3 | řezová metoda | 0.2
zemní práce-rozprostření ornice (ohumusovani) | 67.861 | 2 | no | ((-642758.847211584,-1062698.44962806,232.14),(-642726.668154811,-1062694.10735056,232.755044511)) | 73 | Barva_73 | zemní práce-rozprostření ornice (ohumusovani) | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | zemní práce | OTSKP | 70.03 | 93.94 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ornice | nerelevantni | 165;207;99 | P100 | 3.03852 | řezová metoda | 0.1
zemní práce-rozprostření ornice (ohumusovani) | 60.5728 | 2 | no | ((-642758.769560885,-1062699.62308039,232.14),(-642726.605663941,-1062694.78781679,233.092418364899)) | 73 | Barva_73 | zemní práce-rozprostření ornice (ohumusovani) | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | zemní práce | OTSKP | 70.03 | 94.86 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ornice | nerelevantni | 165;207;99 | P100 | 2.66217 | řezová metoda | 0.1
vozovka_chodník-spodní podkladní vrstva | 66.247 | 2 | no | ((-642758.90387417,-1062698.06587824,232.374024163516),(-642726.711908121,-1062693.61057159,232.685044511)) | 8 | Barva_8 | vozovka_chodník-spodní podkladní vrstva | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | vozovka/chodník | OTSKP | 70.03 | 94.23 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ŠDB | nerelevantni | 128;128;128 | P2 | 4.23234 | řezová metoda | 0.2
zemní práce-zemní krajnice a dosypávky | 33.0617 | 2 | no | ((-642758.892109631,-1062697.8317741,232.52876430067),(-642726.738596993,-1062693.71371506,232.686420042634)) | 8 | Barva_8 | zemní práce-zemní krajnice a dosypávky | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | zemní práce | OTSKP | 70.03 | 94.17 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1 | nerelevantni | D.1.7.4 | nenamrzavý materiál | nerelevantni | 128;128;128 | P100 | 0.558289 | řezová metoda
vozovka_chodník-zpevnění krajnic | 37.8834 | 2 | no | ((-642758.90387417,-1062697.76883961,232.589680510368),(-642726.745768756,-1062693.61057159,232.795044511)) | 8 | Barva_8 | vozovka_chodník-zpevnění krajnic | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | vozovka/chodník | OTSKP | 70.03 | 94.23 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1 | nerelevantni | D.1.7.4 | Recyklovaný materiál | nerelevantni | 128;128;128 | P2 | 1.46326 | řezová metoda
vozovka_chodník-horní podkladní vrstva | 3.34242 | 2 | no | ((-642738.718791645,-1062688.64001524,232.635319885002),(-642727.307403413,-1062673.79460457,232.982635470982)) | 8 | Barva_8 | vozovka_chodník-horní podkladní vrstva | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | vozovka/chodník | OTSKP | 69.99 | 89.93 | horní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ŠDA | ČSN 73 6126-1 | 128;128;128 | P2 | 0.0192104 | řezová metoda | 0.15
vozovka_chodník-horní podkladní vrstva | 6.16824 | 2 | no | ((-642738.718791645,-1062688.64001524,232.583814834497),(-642727.303753437,-1062673.79460457,232.922635470982)) | 8 | Barva_8 | vozovka_chodník-horní podkladní vrstva | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | vozovka/chodník | OTSKP | 69.98 | 89.93 | horní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ŠDA | ČSN 73 6126-1 | 128;128;128 | P2 | 0.0978861 | řezová metoda | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 38.2451 | 2 | no | ((-642738.218791679,-1062688.14060372,232.105925945608),(-642727.251405988,-1062673.91418793,232.942635470982)) | 73 | Barva_73 | zemní práce-rozprostření ornice (ohumusovani) | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | zemní práce | OTSKP | 69.78 | 89.45 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ornice | nerelevantni | 165;207;99 | P100 | 1.68826 | řezová metoda | 0.1
zemní práce-rozprostření ornice (ohumusovani) | 36.2445 | 2 | no | ((-642737.658634184,-1062687.45659297,232.105925945608),(-642727.213863848,-1062674.07874462,232.970625789598)) | 73 | Barva_73 | zemní práce-rozprostření ornice (ohumusovani) | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | zemní práce | OTSKP | 69.63 | 88.79 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ornice | nerelevantni | 165;207;99 | P100 | 1.60002 | řezová metoda | 0.1
vozovka_chodník-spodní podkladní vrstva | 40.211 | 2 | no | ((-642738.718791645,-1062688.64001524,232.33995076416),(-642727.270130959,-1062673.79460457,232.872635470982)) | 8 | Barva_8 | vozovka_chodník-spodní podkladní vrstva | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | vozovka/chodník | OTSKP | 69.86 | 89.93 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ŠDB | nerelevantni | 128;128;128 | P2 | 2.59722 | řezová metoda | 0.2
zemní práce-zemní krajnice a dosypávky | 20.4653 | 2 | no | ((-642738.614979418,-1062688.53632519,232.494690465173),(-642727.281552707,-1062673.819433,232.874011002615)) | 8 | Barva_8 | zemní práce-zemní krajnice a dosypávky | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | zemní práce | OTSKP | 69.9 | 89.83 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1 | nerelevantni | D.1.7.4 | nenamrzavý materiál | nerelevantni | 128;128;128 | P100 | 0.343729 | řezová metoda
vozovka_chodník-zpevnění krajnic | 24.2947 | 2 | no | ((-642738.718791645,-1062688.64001524,232.555606455976),(-642727.284621682,-1062673.79460457,232.982635470982)) | 8 | Barva_8 | vozovka_chodník-zpevnění krajnic | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | vozovka/chodník | OTSKP | 69.91 | 89.93 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1 | nerelevantni | D.1.7.4 | Recyklovaný materiál | nerelevantni | 128;128;128 | P2 | 0.936055 | řezová metoda
propustky-zásypy a obsypy | 51.2301 | 3 | no | ((-642685.58095202,-1062711.71164266,231.129070376791),(-642675.365353842,-1062708.88560563,231.990101423008)) | 40 | Barva_40 | propustky-zásypy a obsypy | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | propustky | OTSKP | 9.42 | 11.41 | zásypy a obsypy | 17511 | I1+S1;3+E1+Z1+M3+F1 | nerelevantni | D.1.7.4 | zemina | ČSN 73 6133 | 255;165;0 | P50 | 6.23384 | řezová metoda | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
propustky-obetonování | 23.8113 | 3 | no | ((-642685.29700723,-1062711.35727948,231.280830573001),(-642675.646480214,-1062709.25598716,231.693052045318)) | 8 | Barva_8 | propustky-obetonování | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | propustky | OTSKP | 9.91 | 10.94 | obetonování | 89952A | I1+S1+E1+Z1+M3+F1 | nerelevantni | D.1.7.4 | beton C20/25nXF3 | nerelevantni | 128;128;128 | P50 | 1.99911 | řezová metoda
propustky-podkladní vrstva | 28.8389 | 3 | no | ((-642685.580904115,-1062711.61479253,231.129070375947),(-642675.365652989,-1062709.00044503,231.347219551242)) | 2 | Barva_2 | propustky-podkladní vrstva | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | propustky | OTSKP | 9.68 | 11.17 | podkladní vrstva | 45152 | I1+S1+E1+Z1+M3+F1 | nerelevantni | D.1.7.4 | štěrkodrť fr. 0/32 | nerelevantni | 255;255;0 | P50 | 1.81511 | řezová metoda
propustky-zpevnění dlažbou | 23.884 | 2 | no | ((-642686.56377755,-1062712.03324514,231.222523270104),(-642674.303270182,-1062708.57115543,232.233582263254)) | 8 | Barva_8 | propustky-zpevnění dlažbou | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | propustky | OTSKP | 9.37 | 11.48 | zpevnění dlažbou | 465512 | I1+S1+E1+Z1+M2+F1 | nerelevantni | D.1.7.4 | lomový kámen, spárováno MC | nerelevantni | 128;128;128 | P50 | CZ_M2 - Způsob stanovení plochy: 3D plocha TIN povrchu; Plocha: 5.19673
propustky-lože | 21.7485 | 2 | no | ((-642686.56377755,-1062712.03324514,231.122523270104),(-642674.303270182,-1062708.57115543,232.033582263254)) | 16 | Barva_16 | propustky-lože | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | propustky | OTSKP | 9.37 | 11.48 | lože | 45131A | I1+S1;4+E1+Z1+M3+F1 | nerelevantni | D.1.7.4 | beton | nerelevantni | 128;0;0 | P50 | 0.853719 | řezová metoda | CZ_S4 - Beton: C20/25nXF3; Specifikace: nerelevantni; Typ betonářské vyztuže: nerelevantni; Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.1.7.4; Návrhová životnost: 25
propustky-propust | 22.6115 | 3 | no | ((-642685.49753378,-1062711.10340094,231.429063224986),(-642675.446234419,-1062709.50968234,231.894222613204)) | 8 | Barva_8 | propustky-propust | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | propustky | OTSKP | 10.32 | 10.54 | propust | 87446 | I1+S1;2+E1+Z1+M1+F1 | nerelevantni | D.1.7.4 | PP | nerelevantni | 128;128;128 | P10 | CZ_S2 - Reference: D.1.7.4; Specifikace: nerelevantni; Typ stavebního výrobku: propustek; Stavební výrobek: PP SN12 DN400; Podrobná specifikace: nerelevantni; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M1 - Délka: 10; Způsob stanovení délky: Délka 3D křivky
zemní práce-rozprostření ornice (ohumusovani) | 2.46243 | 2 | no | ((-642677.012076366,-1062708.88472255,231.335603601277),(-642675.600398574,-1062708.0487467,232.24)) | 73 | Barva_73 | zemní práce-rozprostření ornice (ohumusovani) | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | zemní práce | OTSKP | 11.34 | 12 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ornice | nerelevantni | 165;207;99 | P100 | 0.100608 | řezová metoda | 0.1
zemní práce-rozprostření ornice (ohumusovani) | 1.78581 | 2 | no | ((-642675.702960629,-1062708.69975418,231.335600999346),(-642674.716705015,-1062707.92414838,232.038689147935)) | 73 | Barva_73 | zemní práce-rozprostření ornice (ohumusovani) | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | zemní práce | OTSKP | 11.33 | 12 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ornice | nerelevantni | 165;207;99 | P100 | 0.0712398 | řezová metoda | 0.1
zemní práce-rozprostření ornice (ohumusovani) | 1.97801 | 2 | no | ((-642685.680732022,-1062709.9887723,231.399631693861),(-642684.363893364,-1062709.27274756,232.24)) | 73 | Barva_73 | zemní práce-rozprostření ornice (ohumusovani) | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | zemní práce | OTSKP | 11.45 | 12 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ornice | nerelevantni | 165;207;99 | P100 | 0.0785043 | řezová metoda | 0.1
zemní práce-rozprostření ornice (ohumusovani) | 1.77275 | 2 | no | ((-642686.939732828,-1062710.12242952,231.399642733467),(-642685.622913736,-1062709.44663996,232.136030460853)) | 73 | Barva_73 | zemní práce-rozprostření ornice (ohumusovani) | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | zemní práce | OTSKP | 11.47 | 12 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.7.4 | ornice | nerelevantni | 165;207;99 | P100 | 0.0697154 | řezová metoda | 0.1
zemní práce-výkop_odkop | 2441.07 | 2 | no | ((-642759.006034235,-1062722.04347178,231.295123367443),(-642669.005009573,-1062673.09830974,233.092418364897)) | 36 | Barva_36 | zemní práce-výkop_odkop | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | zemní práce | OTSKP | 0 | 95.38 | výkop/odkop | 12373 | I1+S3+E1+Z1+M3+F1 |  |  |  |  | 125;75;0 | P100 | 319.742 | řezová metoda | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
trasa-průjezdní a průchozí prostor | 0.06 | 3 | yes | ((-642679.108695048,-1062720.68051211,232.28),(-642679.008695048,-1062720.58051211,232.38)) | 9 | Barva_9 | trasa-průjezdní a průchozí prostor |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  | 191;191;191 | P2 | CZ_I3 - Fáze projektu: PDPS; Název (trasy): Účelová komunikace; Staničení od: 0.05; Staničení do: 0.06; Označení elementu: průjezdní a průchozí prostor; Označení průjezdného profilu: nerelevantni; Klasifikační systém: nerelevantni; Označení položky: nerelevantni; Označení šablony vlastností: I3+E1+Z1+F1
C3D-POVRCH | 41.1477 | 4 | no | ((-642685.580904115,-1062711.61479253,231.12),(-642675.365652989,-1062708.99814752,231.79)) | 36 | Barva_36 | C3D-POVRCH | SO 107 | nerelevantni | PDPS | Napojení lesní cesty | zemní práce | OTSKP | 9.68 | 11.17 | výkop/odkop | 13173 | I1+S3+E1+Z1+M3+F1 |  |  |  |  | 125;75;0 | P100 | 8.2123 | řezová metoda | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni

# IfcGeographicElement (2)
In: UnknownName
PredefinedType: TERRAIN
Properties - AutoRebuild: yes; HasSnapshot: no; IsOutOfDate: no; IsSnapshotOutOfDate: no; IsVolumeSurface: no; Lock: no; DisplayName: Povrch TIN; IsReferenceObject: no; IsReferenceStale: no; IsReferenceSubObject: no; IsReferenceValid: no; IsUsed: yes; ShowToolTip: yes; CloneMeForDragging: no; ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: no; IsModifiedGraphics: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no
Miscellaneous - IsHighlighting: no; NeedsPromoting: no; SupportsBaseCurveCommands: no; SupportsProfileCommands: no; SwappingReferences: no; TypeIcon: (Icon)
General - LayerKey: AeccSurfaceTin; Linetype: ByLayer; LinetypeScale: 1; Visible: yes
Geometry - Closed: no; IsPeriodic: no; IsPlanar: yes
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
CZ_I1 - Označení stavebního objektu: SO 107; Označení podobjektu: nerelevantni; Označení části objektu: nerelevantni; Fáze projektu: PDPS; Název stavebního objektu: Napojení lesní cesty; Klasifikační systém: OTSKP; Označení šablony vlastností: I1+S1+E1+Z1+M2+F1
CZ_S1 - podrobná specifikace: nerelevantni; Reference: D.1.7.4
CZ_E1 - Datum zahájení prací: 01.05.2025; Datum dokončení: 30.06.2027; Doba trvání: 790; Datum uvedení do provozu: 01.07.2027; Stavební postup / etapa výstavby: nerelevantni
CZ_M2 - Způsob stanovení plochy: 3D plocha TIN povrchu
CZ_F1 - Fáze: trvalý stav
Name | FingerPrint | Name = Layer | StyleName | Bounds | ColorIndex | PlotStyleName | Staničení od | Staničení do | Označení elementu | Skupina elementů | Označení položky | Materiál | specifikace | Textura / barva | Skupina přesnosti | Plocha
vozovka_chodník-nátěry | -1349358005 | vozovka_chodník-nátěry | nátěry | ((-642859.006034235,-1062822.04347178,232.207218567539),(-642569.005009574,-1062573.09830974,255.885570975486)) | 8 | Barva_8 | 17 | 79.5 | nátěry | vozovka/chodník | 572743 | Dvojvrstvý nátěr z kat. em. | nerelevantni | 128;128;128 | P2 | 770.248
zemní práce-pláň | 1634309181 | zemní práce-pláň | plan | ((-642859.006034235,-1062822.04347178,231.850049660529),(-642569.005009574,-1062573.09830974,232.65)) | 96 | Barva_96 | 2.05 | 93.74 | pláň | zemní práce | 18110 | nerelevantni | ČSN 73 6133 | 0;128;0 | P10 | 1052.37
