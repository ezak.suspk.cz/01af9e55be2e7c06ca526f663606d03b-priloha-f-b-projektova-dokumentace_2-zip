Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [Ifc4X3NotAssigned]
File name: D:\_Projekty\2017_07 - SÚS Obchvat Dašic\4_PDPS\BIM\IFC\SO 102.ifc
Time: 2025-03-12T09:10:37
Author: Michal Švarc
Organization: DESKTOP-47J51D1
Written by: GeometryGymIFCcore v24.8.23.0 by Geometry Gym Pty Ltd built 2024-08-23T03:53:20
Made in: Civil 3D 2024 IfcInfra Plugin v13.6.170.0
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcProject, SO 102
Summary - Title: CAD Studio Silniční šablona; Author: Martin Folber, Ondřej Vojtěchovský, Jakub Kareš; HyperlinkBase: www.cadstudio.cz
Custom_Properties - Investor: Správa a údržba silnic Pardubického kraje, Doubravice 98, 533 53 Pardubice; Stupeň PD: DÚSP; Příloha č.: 2.; Část: D; Datum PD: 02.2022; Místo: Pardubický kraj/obec

# IfcBuiltElement (81)
In: UnknownName
Properties - ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: no; IsModifiedGraphics: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no; CloneMeForDragging: yes; IsNull: no; UsesGraphicsCache: yes
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
General - Linetype: ByLayer; LinetypeScale: 1; Visible: yes
Geometry - IsPlanar: no
CZ_F1 - Fáze: trvalý stav
CZ_E1 - Datum zahájení prací: 01.05.2025; Datum dokončení: 30.06.2027; Doba trvání: 790; Datum uvedení do provozu: 01.07.2027
Name | Area | NumChanges | RecordHistory = ShowHistory | Bounds | ColorIndex | Layer | PlotStyleName | Skupina přesnosti | Textura / barva | Objem | Způsob stanovení objemu | Tloušťka | Označení stavebního objektu | Označení podobjektu = Označení části objektu | CZ_I1, Fáze projektu | Název stavebního objektu | CZ_I1, Klasifikační systém | CZ_I1, Staničení od | CZ_I1, Staničení do | CZ_I1, Označení elementu | Skupina elementů | CZ_I1, Označení položky | CZ_I1, Označení šablony vlastností | podrobná specifikace | CZ_S1, Reference | Materiál | specifikace | Stavební postup / etapa výstavby
vozovka_chodník-obrusná vrstva | 1581.72 | 1 | no | ((-642984.847035026,-1062712.08014932,232.157269217256),(-642800.553558061,-1062641.40241467,233.28295446696)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | P2 | 128;128;128 | 31.3047 | řezová metoda | 0.04 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0.0193 | 0.21533 | obrusná vrstva | vozovka/chodník | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | nerelevantni
vozovka_chodník-ložní vrstva | 1585.71 | 1 | no | ((-642984.847035026,-1062712.08014932,232.107269217256),(-642800.553558061,-1062641.40241467,233.24295446696)) | 8 | vozovka_chodník-ložní vrstva | Barva_8 | P2 | 128;128;128 | 39.1309 | řezová metoda | 0.05 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0.0193 | 0.21533 | ložní vrstva | vozovka/chodník | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | nerelevantni
vozovka_chodník-podkladní asfaltová vrstva | 1589.7 | 1 | no | ((-642984.847035026,-1062712.08014932,232.047269217256),(-642800.553558061,-1062641.40241467,233.19295446696)) | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | P2 | 128;128;128 | 46.9571 | řezová metoda | 0.06 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0.0193 | 0.21533 | podkladní asfaltová vrstva | vozovka/chodník | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | nerelevantni
vozovka_chodník-horní podkladní vrstva | 1625.64 | 1 | no | ((-642984.847035026,-1062712.08014932,231.897269217256),(-642800.553558061,-1062641.40241467,233.13295446696)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | P2 | 128;128;128 | 117.393 | řezová metoda | 0.15 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0.0193 | 0.21533 | horní podkladní vrstva | vozovka/chodník | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | MZK | ČSN 73 6126-1 | nerelevantni
vozovka_chodník-spodní podkladní vrstva | 1649.7 | 1 | no | ((-642984.847035026,-1062712.08014932,231.677269217256),(-642800.553558061,-1062641.40241467,232.98295446696)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | P2 | 128;128;128 | 164.345 | řezová metoda | 0.2 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0.0193 | 0.21533 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | ŠDA | ČSN 73 6126-1 | nerelevantni
vozovka_chodník-obrusná vrstva | 20.6123 | 1 | no | ((-642983.257557424,-1062708.17866106,232.156762888142),(-642800.549090902,-1062641.38382918,233.18295446696)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | P2 | 128;128;128 | 0.0791099 | řezová metoda | 0.04 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0.0193 | 0.21533 | obrusná vrstva | vozovka/chodník | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | nerelevantni
vozovka_chodník-ložní vrstva | 53.2179 | 1 | no | ((-642983.257557424,-1062708.17866106,232.10487997675),(-642800.532478657,-1062641.31471438,233.14295446696)) | 8 | vozovka_chodník-ložní vrstva | Barva_8 | P2 | 128;128;128 | 0.809536 | řezová metoda | 0.05 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0.0193 | 0.21533 | ložní vrstva | vozovka/chodník | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | nerelevantni
vozovka_chodník-podkladní asfaltová vrstva | 87.8026 | 1 | no | ((-642983.257557424,-1062708.17866106,232.042870483079),(-642800.514749623,-1062641.2409532,233.09295446696)) | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | P2 | 128;128;128 | 1.88348 | řezová metoda | 0.06 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0.0193 | 0.21533 | podkladní asfaltová vrstva | vozovka/chodník | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | nerelevantni
vozovka_chodník-horní podkladní vrstva | 237.7 | 1 | no | ((-642983.257557424,-1062708.17866106,231.884526327235),(-642800.441132159,-1062640.9346697,233.03295446696)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | P2 | 128;128;128 | 11.5048 | řezová metoda | 0.15 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0.0193 | 0.21533 | horní podkladní vrstva | vozovka/chodník | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | MZK | ČSN 73 6126-1 | nerelevantni
vozovka_chodník-spodní podkladní vrstva | 685.54 | 1 | no | ((-642983.257557424,-1062708.17866106,231.628746645166),(-642800.196810499,-1062639.91817593,232.88295446696)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | P2 | 128;128;128 | 50.7501 | řezová metoda | 0.2 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0.0193 | 0.21533 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | ŠDA | ČSN 73 6126-1 | nerelevantni
zemní práce-rozprostření ornice (ohumusovani) | 1825.26 | 1 | no | ((-642982.973283962,-1062707.48089119,231.265647595635),(-642799.740529358,-1062636.58198826,234.006284774445)) | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | P100 | 165;207;99 | 126.941 | řezová metoda | 0.15 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0.0193 | 0.21533 | rozprostření ornice (ohumusovani) | zemní práce | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | ornice | nerelevantni | nerelevantni
zemní práce-zemní krajnice a dosypávky | 375.461 | 1 | no | ((-642983.137298941,-1062707.88347787,231.790981763889),(-642800.286269354,-1062640.29036712,233.00826431274)) | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | P100 | 128;128;128 | 16.6953 | řezová metoda |  | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0.0193 | 0.21533 | zemní krajnice a dosypávky | zemní práce | 173103 | I1+S1+E1+Z1+M3+F1 | nerelevantni | D.1.2.4 | nenamrzavý materiál | VL 1 | nerelevantni
vozovka_chodník-obrusná vrstva | 1587.74 | 1 | no | ((-642986.436512628,-1062715.98163758,232.157269217256),(-642801.43582183,-1062645.07304963,233.28295446696)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | P2 | 128;128;128 | 31.424 | řezová metoda | 0.04 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0.0193 | 0.21533 | obrusná vrstva | vozovka/chodník | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | nerelevantni
vozovka_chodník-ložní vrstva | 1591.75 | 1 | no | ((-642986.436512628,-1062715.98163758,232.107269217256),(-642801.43582183,-1062645.07304963,233.24295446696)) | 8 | vozovka_chodník-ložní vrstva | Barva_8 | P2 | 128;128;128 | 39.2799 | řezová metoda | 0.05 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0.0193 | 0.21533 | ložní vrstva | vozovka/chodník | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | nerelevantni
vozovka_chodník-podkladní asfaltová vrstva | 1595.76 | 1 | no | ((-642986.436512628,-1062715.98163758,232.047269217256),(-642801.43582183,-1062645.07304963,233.19295446696)) | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | P2 | 128;128;128 | 47.1359 | řezová metoda | 0.06 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0.0193 | 0.21533 | podkladní asfaltová vrstva | vozovka/chodník | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | nerelevantni
vozovka_chodník-horní podkladní vrstva | 1631.83 | 1 | no | ((-642986.436512628,-1062715.98163758,231.897269217256),(-642801.43582183,-1062645.07304963,233.13295446696)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | P2 | 128;128;128 | 117.84 | řezová metoda | 0.15 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0.0193 | 0.21533 | horní podkladní vrstva | vozovka/chodník | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | MZK | ČSN 73 6126-1 | nerelevantni
vozovka_chodník-spodní podkladní vrstva | 1655.99 | 1 | no | ((-642986.436512628,-1062715.98163758,231.677269217256),(-642801.43582183,-1062645.07304963,232.98295446696)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | P2 | 128;128;128 | 164.981 | řezová metoda | 0.2 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0.0193 | 0.21533 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | ŠDA | ČSN 73 6126-1 | nerelevantni
vozovka_chodník-obrusná vrstva | 20.7698 | 1 | no | ((-642986.444560616,-1062716.00139195,232.156762888142),(-642802.318085599,-1062648.74368458,233.18295446696)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | P2 | 128;128;128 | 0.0796969 | řezová metoda | 0.04 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0.0193 | 0.21533 | obrusná vrstva | vozovka/chodník | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | nerelevantni
vozovka_chodník-ložní vrstva | 53.6283 | 1 | no | ((-642986.474489071,-1062716.07485352,232.10487997675),(-642802.318085599,-1062648.74368458,233.14295446696)) | 8 | vozovka_chodník-ložní vrstva | Barva_8 | P2 | 128;128;128 | 0.815752 | řezová metoda | 0.05 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0.0193 | 0.21533 | ložní vrstva | vozovka/chodník | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | nerelevantni
vozovka_chodník-podkladní asfaltová vrstva | 88.4862 | 1 | no | ((-642986.506429523,-1062716.15325367,232.042870483079),(-642802.318085599,-1062648.74368458,233.09295446696)) | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | P2 | 128;128;128 | 1.89811 | řezová metoda | 0.06 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0.0193 | 0.21533 | podkladní asfaltová vrstva | vozovka/chodník | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | nerelevantni
vozovka_chodník-horní podkladní vrstva | 239.617 | 1 | no | ((-642986.639058011,-1062716.47879994,231.884526327235),(-642802.318085599,-1062648.74368458,233.03295446696)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | P2 | 128;128;128 | 11.597 | řezová metoda | 0.15 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0.0193 | 0.21533 | horní podkladní vrstva | vozovka/chodník | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | MZK | ČSN 73 6126-1 | nerelevantni
vozovka_chodník-spodní podkladní vrstva | 691.768 | 1 | no | ((-642987.079225474,-1062717.55922296,231.628746645166),(-642802.318085599,-1062648.74368458,232.88295446696)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | P2 | 128;128;128 | 51.1999 | řezová metoda | 0.2 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0.0193 | 0.21533 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | ŠDA | ČSN 73 6126-1 | nerelevantni
zemní práce-rozprostření ornice (ohumusovani) | 1640.44 | 1 | no | ((-642988.529522493,-1062719.0724412,231.265647595635),(-642802.475875917,-1062649.400167,233.075227162885)) | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | P100 | 165;207;99 | 112.961 | řezová metoda | 0.15 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0.0193 | 0.21533 | rozprostření ornice (ohumusovani) | zemní práce | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | ornice | nerelevantni | nerelevantni
zemní práce-zemní krajnice a dosypávky | 378.865 | 1 | no | ((-642986.918057295,-1062717.16362395,231.790981763889),(-642802.384836903,-1062649.02140161,233.00826431274)) | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | P100 | 128;128;128 | 16.8462 | řezová metoda |  | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0.0193 | 0.21533 | zemní krajnice a dosypávky | zemní práce | 173103 | I1+S1+E1+Z1+M3+F1 | nerelevantni | D.1.2.4 | nenamrzavý materiál | VL 1 | nerelevantni
vozovka_chodník-obrusná vrstva | 1.66754 | 1 | no | ((-643000.93551015,-1062648.76227007,232.09807729782),(-642986.436512628,-1062642.4687376,232.197866771383)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | P2 | 128;128;128 | 0.00639644 | řezová metoda | 0.04 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0.21533 | 0.23112 | obrusná vrstva | vozovka/chodník | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | nerelevantni
vozovka_chodník-ložní vrstva | 4.31125 | 1 | no | ((-643000.965438605,-1062648.83138488,232.046194386428),(-642986.436512628,-1062642.4687376,232.157866771383)) | 8 | vozovka_chodník-ložní vrstva | Barva_8 | P2 | 128;128;128 | 0.0654636 | řezová metoda | 0.05 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0.21533 | 0.23112 | ložní vrstva | vozovka/chodník | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | nerelevantni
vozovka_chodník-podkladní asfaltová vrstva | 7.11844 | 1 | no | ((-643000.997379057,-1062648.90514605,231.984184892757),(-642986.436512628,-1062642.4687376,232.107866771383)) | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | P2 | 128;128;128 | 0.152315 | řezová metoda | 0.06 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0.21533 | 0.23112 | podkladní asfaltová vrstva | vozovka/chodník | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | nerelevantni
vozovka_chodník-horní podkladní vrstva | 19.3342 | 1 | no | ((-643001.130007545,-1062649.21142955,231.825840736912),(-642986.436512628,-1062642.4687376,232.047866771383)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | P2 | 128;128;128 | 0.930496 | řezová metoda | 0.15 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0.21533 | 0.23112 | horní podkladní vrstva | vozovka/chodník | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | MZK | ČSN 73 6126-1 | nerelevantni
vozovka_chodník-spodní podkladní vrstva | 57.1576 | 1 | no | ((-643001.656092717,-1062650.22792332,231.542857712806),(-642986.436512628,-1062642.4687376,231.897866771383)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | P2 | 128;128;128 | 4.29948 | řezová metoda | 0.2 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0.21533 | 0.23112 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | ŠDA | ČSN 73 6126-1 | nerelevantni
zemní práce-rozprostření ornice (ohumusovani) | 150.468 | 1 | no | ((-643002.83500536,-1062653.5771438,231.179758663275),(-642986.72078609,-1062643.12522002,232.772203918794)) | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | P100 | 165;207;99 | 10.3845 | řezová metoda | 0.15 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0.21533 | 0.23112 | rozprostření ornice (ohumusovani) | zemní práce | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | ornice | nerelevantni | nerelevantni
zemní práce-zemní krajnice a dosypávky | 31.5608 | 1 | no | ((-643001.494924537,-1062649.85573214,231.705092831529),(-642986.556771112,-1062642.74645462,232.023176617163)) | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | P100 | 128;128;128 | 1.43631 | řezová metoda |  | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0.21533 | 0.23112 | zemní krajnice a dosypávky | zemní práce | 173103 | I1+S1+E1+Z1+M3+F1 | nerelevantni | D.1.2.4 | nenamrzavý materiál | VL 1 | nerelevantni
vozovka_chodník-obrusná vrstva | 2.54824 | 1 | no | ((-642992.297006734,-1062641.40250389,232.049493670886),(-642983.24954821,-1062621.14632065,232.319999999832)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | P2 | 128;128;128 | 0.00977557 | řezová metoda | 0.04 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0.21533 | 0.23033 | obrusná vrstva | vozovka/chodník | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | nerelevantni
vozovka_chodník-ložní vrstva | 6.56898 | 1 | no | ((-642992.297006734,-1062641.40250389,231.997610759494),(-642983.219620279,-1062621.14632065,232.279999999832)) | 8 | vozovka_chodník-ložní vrstva | Barva_8 | P2 | 128;128;128 | 0.0998139 | řezová metoda | 0.05 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0.21533 | 0.23033 | ložní vrstva | vozovka/chodník | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | nerelevantni
vozovka_chodník-podkladní asfaltová vrstva | 10.815 | 1 | no | ((-642992.297006734,-1062641.40250389,231.935601265823),(-642983.187680386,-1062621.14632065,232.229999999832)) | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | P2 | 128;128;128 | 0.231638 | řezová metoda | 0.06 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0.21533 | 0.23033 | podkladní asfaltová vrstva | vozovka/chodník | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | nerelevantni
vozovka_chodník-horní podkladní vrstva | 29.0544 | 1 | no | ((-642992.297006734,-1062641.40250389,231.777257109979),(-642983.055054219,-1062621.14632065,232.169999999832)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | P2 | 128;128;128 | 1.40358 | řezová metoda | 0.15 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0.21533 | 0.23033 | horní podkladní vrstva | vozovka/chodník | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | MZK | ČSN 73 6126-1 | nerelevantni
vozovka_chodník-spodní podkladní vrstva | 85.4838 | 1 | no | ((-642992.297006734,-1062641.40250389,231.489044995477),(-642982.582675882,-1062621.14632065,232.019999999832)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | P2 | 128;128;128 | 6.80374 | řezová metoda | 0.2 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0.21533 | 0.23033 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | ŠDA | ČSN 73 6126-1 | nerelevantni
zemní práce-rozprostření ornice (ohumusovani) | 190.554 | 1 | no | ((-642991.581625606,-1062640.74601931,231.125945945946),(-642981.113908949,-1062621.45255722,232.765774827811)) | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | P100 | 165;207;99 | 13.1259 | řezová metoda | 0.15 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0.21533 | 0.22961 | rozprostření ornice (ohumusovani) | zemní práce | 18220 |  | nerelevantni | D.1.2.4 | ornice | nerelevantni | nerelevantni
zemní práce-zemní krajnice a dosypávky | 48.2644 | 1 | no | ((-642991.994373316,-1062641.12478595,231.651280114201),(-642982.743841241,-1062621.27587036,232.145309845612)) | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | P100 | 128;128;128 | 2.30616 | řezová metoda |  | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0.21533 | 0.23003 | zemní krajnice a dosypávky | zemní práce | 173103 |  | nerelevantni | CDE 1.7.3.2 PDF - D.1.2.4 | nenamrzavý materiál | VL 1 | nerelevantni
vozovka_chodník-obrusná vrstva | 145.064 | 1 | no | ((-643011.276405164,-1062642.46876919,232.16),(-642990.947933721,-1062620.76359527,232.39)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | P2 | 128;128;128 | 2.84336 | řezová metoda | 0.04 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 230.46 | 231.12 | obrusná vrstva | vozovka/chodník | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | nerelevantni
vozovka_chodník-ložní vrstva | 130.958 | 1 | no | ((-643011.276405164,-1062642.46876919,232.11),(-642990.947933721,-1062620.87061291,232.348999204993)) | 8 | vozovka_chodník-ložní vrstva | Barva_8 | P2 | 128;128;128 | 3.18384 | řezová metoda | 0.05 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 230.46 | 231.12 | ložní vrstva | vozovka/chodník | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | nerelevantni
vozovka_chodník-podkladní asfaltová vrstva | 116.605 | 1 | no | ((-643011.276405164,-1062642.46876919,232.05),(-642990.947933721,-1062620.97763055,232.297998409985)) | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | P2 | 128;128;128 | 3.36873 | řezová metoda | 0.06 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 230.46 | 231.12 | podkladní asfaltová vrstva | vozovka/chodník | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | nerelevantni
vozovka_chodník-horní podkladní vrstva | 123.648 | 1 | no | ((-643011.475102947,-1062642.46876919,231.9),(-642990.947933721,-1062620.97763055,232.237998409984)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | P2 | 128;128;128 | 8.44723 | řezová metoda | 0.15 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 230.46 | 231.12 | horní podkladní vrstva | vozovka/chodník | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | MZK | ČSN 73 6126-1 | nerelevantni
vozovka_chodník-spodní podkladní vrstva | 127.305 | 1 | no | ((-643011.475102947,-1062642.46876919,231.7),(-642990.947933721,-1062620.97763055,232.087998409984)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | P2 | 128;128;128 | 11.2655 | řezová metoda | 0.2 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 230.46 | 231.12 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | ŠDA | ČSN 73 6126-1 | 0
trubní vedení-potrubí | 1.48205 | 2 | no | ((-643001.121477271,-1062641.9267316,231.450899785391),(-642999.763904396,-1062639.04991387,231.600899785391)) | 4 | trubní vedení-potrubí | Barva_4 | P10 | 0;255;255 |  |  |  | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0 | 0 | potrubí | trubní vedení | 87433 | I1+S3+E1+Z1+M1+F1 | nerelevantni | D.1.2.4 | PP SN 12 DN150 | nerelevantni | nerelevantni | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: PP SN12 DN150; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 3.5
zemní práce-podkladní a výplňové vrstvy | 3.335 | 2 | no | ((-643001.820203538,-1062642.81878196,230.864111794313),(-643000.403395202,-1062641.4046355,231.046775032003)) | 8 | zemní práce-podkladní a výplňové vrstvy | Barva_8 | P100 | 128;128;128 | 0.198375 | řezová metoda |  | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 230.78 | 230.95 | podkladní a výplňové vrstvy | zemní práce | 45157 | I1+S3+E1+Z1+M3+F1 |  |  |  |  | nerelevantni | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: ŠP
zemní práce-podkladní a výplňové vrstvy | 3.335 | 2 | no | ((-643011.824569346,-1062638.486639,230.884111794319),(-643010.40776101,-1062637.07249254,231.066775032009)) | 8 | zemní práce-podkladní a výplňové vrstvy | Barva_8 | P100 | 128;128;128 | 0.198375 | řezová metoda |  | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0 | 0 | podkladní a výplňové vrstvy | zemní práce | 45157 | I1+S3+E1+Z1+M3+F1 |  |  |  |  | nerelevantni | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: ŠP
zemní práce-výkop rýhy | 5.865 | 2 | no | ((-643001.83941359,-1062642.81765338,231.014051052781),(-643000.407511642,-1062641.39936879,231.746491571521)) | 36 | zemní práce-výkop rýhy | Barva_36 | P100 | 125;75;0 | 0.92575 | řezová metoda |  | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 230.78 | 230.96 | výkop rýhy | zemní práce | 13273 | I1+S3+E1+Z1+M3+F1 |  |  |  |  | nerelevantni | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
zemní práce-výkop rýhy | 5.865 | 2 | no | ((-643011.843779398,-1062638.48551042,231.034051052744),(-643010.411877449,-1062637.06722583,231.766491571483)) | 36 | zemní práce-výkop rýhy | Barva_36 | P100 | 125;75;0 | 0.92575 | řezová metoda |  | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0 | 0 | výkop rýhy | zemní práce | 13273 | I1+S3+E1+Z1+M3+F1 |  |  |  |  | nerelevantni | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
trubní vedení-podsyp | 4.785 | 2 | no | ((-643001.327950487,-1062642.01613972,231.300899785391),(-642999.557431181,-1062638.96050575,231.450899785391)) | 2 | trubní vedení-podsyp | Barva_2 | P50 | 255;255;0 | 0.2763 | řezová metoda |  | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0 | 0 | podsyp | trubní vedení | 45157 | I1+S3+E1+Z1+M3+F1 | nerelevantni | D.1.2.4 | ŠP | nerelevantni | nerelevantni
trubní vedení-podsyp | 4.785 | 2 | no | ((-643011.332316295,-1062637.68399675,231.320899785397),(-643009.561796988,-1062634.62836279,231.470899785397)) | 2 | trubní vedení-podsyp | Barva_2 | P50 | 255;255;0 | 0.2763 | řezová metoda |  | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0 | 0 | podsyp | trubní vedení | 45157 | I1+S3+E1+Z1+M3+F1 | nerelevantni | D.1.2.4 | ŠP | nerelevantni | nerelevantni
trubní vedení-obsyp | 7.66436 | 2 | no | ((-643001.327950487,-1062642.01613972,231.450899785391),(-642999.557431181,-1062638.96050575,231.800899785391)) | 40 | trubní vedení-obsyp | Barva_40 | P50 | 255;165;0 | 0.590449 | řezová metoda | 0.3 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0 | 0 | obsyp | trubní vedení | 17581 | I1+S2+E1+Z1+M3;2&6+F1 |  |  |  |  | nerelevantni | CZ_S2 - Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: ŠP; Stavební výrobek: nerelevantni; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.1.4.4
trubní vedení-obsyp | 7.66436 | 2 | no | ((-643011.332316295,-1062637.68399675,231.470899785397),(-643009.561796988,-1062634.62836279,231.820899785397)) | 40 | trubní vedení-obsyp | Barva_40 | P50 | 255;165;0 | 0.590449 | řezová metoda | 0.3 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0 | 0 | obsyp | trubní vedení | 17581 | I1+S2+E1+Z1+M3;2&6+F1 |  |  |  |  | nerelevantni | CZ_S2 - Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: ŠP; Stavební výrobek: nerelevantni; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.1.4.4
trubní vedení-potrubí | 1.48205 | 2 | no | ((-643011.125843079,-1062637.59458864,231.470899785397),(-643009.768270204,-1062634.71777091,231.620899785397)) | 4 | trubní vedení-potrubí | Barva_4 | P10 | 0;255;255 |  |  |  | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0 | 0 | potrubí | trubní vedení | 87433 | I1+S3+E1+Z1+M1+F1 | nerelevantni | D.1.2.4 | PP SN 12 DN150 | nerelevantni | nerelevantni | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: PP SN12 DN150; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 3.5
zemní práce-výkop rýhy | 12.8213 | 2 | no | ((-643001.841105582,-1062642.81878196,230.864111794313),(-642999.557431181,-1062638.96050575,231.808121536974)) | 36 | zemní práce-výkop rýhy | Barva_36 | P100 | 125;75;0 | 2.02152 | řezová metoda |  | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 230.78 | 230.97 | výkop rýhy | zemní práce | 13273 | I1+S3+E1+Z1+M3+F1 |  |  |  |  | nerelevantni | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
zemní práce-výkop rýhy | 12.8213 | 2 | no | ((-643011.84547139,-1062638.486639,230.884111794319),(-643009.561796988,-1062634.62836279,231.828121536975)) | 36 | zemní práce-výkop rýhy | Barva_36 | P100 | 125;75;0 | 2.02152 | řezová metoda |  | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0 | 0 | výkop rýhy | zemní práce | 13273 | I1+S3+E1+Z1+M3+F1 |  |  |  |  | nerelevantni | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
objekty na TV-uliční vpusť | 2.41812 | 2 | no | ((-643001.470606413,-1062642.43222713,231.024010524728),(-643000.813092344,-1062641.77471306,232.21)) | 4 | objekty na TV-uliční vpusť | Barva_4 | P10 | 0;255;255 |  |  |  | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0 | 0 | uliční vpusť | objekty na TV | 89712 | I1+S2+E1+Z1+M4+F1 |  |  |  |  | nerelevantni | CZ_S2 - Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: uliční vpusť; Stavební výrobek: nerelevantni; Specifikace: mříž D400, bet. dílce DN450, přípojka DN150; Podrobná specifikace: nerelevantni; Reference: CDE 1.7.3.2 PDF - D.1.4.4; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
objekty na TV-uliční vpusť | 2.41812 | 2 | no | ((-643011.474972221,-1062638.10008416,231.044010524728),(-643010.817458152,-1062637.44257009,232.23)) | 4 | objekty na TV-uliční vpusť | Barva_4 | P10 | 0;255;255 |  |  |  | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0 | 0 | uliční vpusť | objekty na TV | 89712 | I1+S2+E1+Z1+M4+F1 |  |  |  |  | nerelevantni | CZ_S2 - Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: uliční vpusť; Stavební výrobek: nerelevantni; Specifikace: mříž D400, bet. dílce DN450, přípojka DN150; Podrobná specifikace: nerelevantni; Reference: CDE 1.7.3.2 PDF - D.1.4.4; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
zemní práce-výkop_odkop | 7777.07 | 1 | no | ((-643002.835078879,-1062719.39749884,231.125945945946),(-642799.740529358,-1062620.97679473,234.020623758298)) | 36 | zemní práce-výkop_odkop | Barva_36 | P100 | 125;75;0 | 2948.43 | řezová metoda |  | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 19.3 | 231.12 | výkop/odkop | zemní práce | 12373 | I1+S3+E1+Z1+M3+F1 |  |  |  |  | nerelevantni | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
vozovka_chodník-obrusná vrstva | 237.394 | 1 | no | ((-642999.337911975,-1062645.07304963,232.05),(-642983.257596057,-1062621.06812985,232.324647624324)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | P2 | 128;128;128 | 4.69288 | řezová metoda | 0.04 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 215.33 | 231.12 | obrusná vrstva | vozovka/chodník | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | nerelevantni
vozovka_chodník-ložní vrstva | 238.031 | 1 | no | ((-642999.337911993,-1062645.07304963,232),(-642983.257596057,-1062621.06812985,232.284647624324)) | 8 | vozovka_chodník-ložní vrstva | Barva_8 | P2 | 128;128;128 | 5.8661 | řezová metoda | 0.05 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 215.33 | 231.12 | ložní vrstva | vozovka/chodník | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | nerelevantni
vozovka_chodník-podkladní asfaltová vrstva | 238.667 | 1 | no | ((-642999.337911993,-1062645.07304963,231.94),(-642983.257596057,-1062621.06812985,232.234647624324)) | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | P2 | 128;128;128 | 7.03931 | řezová metoda | 0.06 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 215.33 | 231.12 | podkladní asfaltová vrstva | vozovka/chodník | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | nerelevantni
vozovka_chodník-horní podkladní vrstva | 244.396 | 1 | no | ((-642999.337911993,-1062645.07304963,231.79),(-642983.257596057,-1062621.06812985,232.174647624324)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | P2 | 128;128;128 | 17.5982 | řezová metoda | 0.15 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 215.33 | 231.12 | horní podkladní vrstva | vozovka/chodník | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | MZK | ČSN 73 6126-1 | nerelevantni
vozovka_chodník-spodní podkladní vrstva | 249.83 | 1 | no | ((-642999.337947403,-1062645.07304963,231.540701895357),(-642983.257596057,-1062621.06812985,232.024647624324)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | P2 | 128;128;128 | 26.4942 | řezová metoda | 0.2 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 215.33 | 231.12 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | ŠDA | ČSN 73 6126-1 | nerelevantni
vozovka_chodník-obrusná vrstva | 127.949 | 1 | no | ((-643000.927462162,-1062648.74368458,232.098583626934),(-642984.847035026,-1062638.79810265,232.297269217256)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | P2 | 128;128;128 | 2.52659 | řezová metoda | 0.04 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 215.33 | 231.12 | obrusná vrstva | vozovka/chodník | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | nerelevantni
vozovka_chodník-ložní vrstva | 128.344 | 1 | no | ((-643000.927462162,-1062648.74368458,232.048583626934),(-642984.847035026,-1062638.79810265,232.257269217256)) | 8 | vozovka_chodník-ložní vrstva | Barva_8 | P2 | 128;128;128 | 3.15824 | řezová metoda | 0.05 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 215.33 | 231.12 | ložní vrstva | vozovka/chodník | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | nerelevantni
vozovka_chodník-podkladní asfaltová vrstva | 128.74 | 1 | no | ((-643000.927462162,-1062648.74368458,231.988583626934),(-642984.847035026,-1062638.79810265,232.207269217256)) | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | P2 | 128;128;128 | 3.78989 | řezová metoda | 0.06 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 215.33 | 231.12 | podkladní asfaltová vrstva | vozovka/chodník | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | nerelevantni
vozovka_chodník-horní podkladní vrstva | 132.303 | 1 | no | ((-643000.927462162,-1062648.74368458,231.838583626934),(-642984.847035026,-1062638.79810265,232.147269217256)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | P2 | 128;128;128 | 9.47473 | řezová metoda | 0.15 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 215.33 | 231.12 | horní podkladní vrstva | vozovka/chodník | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | MZK | ČSN 73 6126-1 | nerelevantni
vozovka_chodník-spodní podkladní vrstva | 135.014 | 1 | no | ((-643000.927462162,-1062648.74368458,231.597866771383),(-642984.847035026,-1062638.79810265,231.997269217256)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | P2 | 128;128;128 | 13.5942 | řezová metoda | 0.2 | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 215.33 | 231.12 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.2.4 | ŠDA | ČSN 73 6126-1 | nerelevantni
vozovka_chodník-obrubník | 12.9359 | 1 | no | ((-643011.672226442,-1062642.60236699,231.960280793663),(-643000.936744332,-1062633.25700594,232.470000000112)) | 40 | vozovka_chodník-obrubník | Barva_40 | P2 | 255;165;0 |  |  |  | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0 | 0 | obrubník | vozovka/chodník | 917224 | I1+S2+E1+Z1+M1+F1 |  |  |  |  | nerelevantni | CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 0; CZ_S2 - Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: silniční obruba; Stavební výrobek: 15/25/100 cm bet. lože C20/25nXF3; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.1.4.4
vozovka_chodník-obrubník | 17.9055 | 1 | no | ((-643011.882630944,-1062642.74919239,231.860280793663),(-643000.936744332,-1062633.19342684,232.370000000112)) | 40 | vozovka_chodník-obrubník | Barva_40 | P2 | 255;165;0 |  |  |  | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0 | 0 | obrubník | vozovka/chodník | 917224 | I1+S2+E1+Z1+M1+F1 |  |  |  |  | nerelevantni | CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 17.6; CZ_S2 - Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: silniční obruba; Stavební výrobek: 15/25/100 cm bet. lože C20/25nXF3; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.1.4.4
propustky-podkladní vrstva | 15.5467 | 1 | no | ((-643011.882630944,-1062642.74919239,231.710280793663),(-643000.936744332,-1062633.19342684,232.120000000112)) | 2 | propustky-podkladní vrstva | Barva_2 | P50 | 255;255;0 | 0.780735 | řezová metoda |  | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 0 | 0 | podkladní vrstva | propustky | 45152 | I1+S1+E1+Z1+M3+F1 | nerelevantni | D.1.2.4 | ŠD fr. 0/32 | podkladní vrstva obruby | nerelevantni
vozovka_chodník-zpevnění krajnic | 503.439 | 1 | no | ((-642983.257557425,-1062708.17866106,231.949769170806),(-642800.284743318,-1062640.28401441,233.18295446696)) | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | P2 | 128;128;128 | 25.6015 | řezová metoda |  | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 19.3 | 215.33 | zpevnění krajnic | vozovka/chodník | 56960 | I1+S1+E1+Z1+M3+F1 | nerelevantni | D.1.2.4 | Recyklovaný materiál | VL 1 | nerelevantni
vozovka_chodník-zpevnění krajnic | 548.564 | 1 | no | ((-643001.411829081,-1062717.17037228,231.870366371591),(-642802.318085599,-1062642.468706,233.18295446696)) | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | P2 | 128;128;128 | 27.8955 | řezová metoda |  | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 19.3 | 231.12 | zpevnění krajnic | vozovka/chodník | 56960 | I1+S1+E1+Z1+M3+F1 | nerelevantni | D.1.2.4 | Recyklovaný materiál | VL 1 | nerelevantni
vozovka_chodník-zpevnění krajnic | 60.056 | 1 | no | ((-642992.297124518,-1062641.40250389,231.842499999851),(-642982.773310576,-1062621.14632065,232.319999999832)) | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | P2 | 128;128;128 | 3.05054 | řezová metoda |  | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 215.33 | 230.33 | zpevnění krajnic | vozovka/chodník | 56960 | I1+S1+E1+Z1+M3+F1 | nerelevantni | D.1.2.4 | Recyklovaný materiál | VL 1 | nerelevantni
dopravní značení-svislé dopravní značení | 0.587153 | 2 | yes | ((-642800.683326386,-1062706.94906305,232.933694573873),(-642800.605114976,-1062706.87085164,235.284220693953)) | 7 | dopravní značení-svislé dopravní značení | Barva_7 | P10 | 255;255;255 |  |  |  | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 19.5 | 19.5 | svislé dopravní značení | dopravní značení | 914924 | I1+S2+E1+Z1+M4+F1 |  |  |  |  | nerelevantni | CZ_S2 - Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: sloupek; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; Reference: D.1.2.6; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.869588 | 2 | yes | ((-642893.479079205,-1062690.29524176,232.5),(-642893.400867795,-1062690.21703035,236)) | 7 | dopravní značení-svislé dopravní značení | Barva_7 | P10 | 255;255;255 |  |  |  | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 113.38 | 113.38 | svislé dopravní značení | dopravní značení | 914981 | I1+S2+E1+Z1+M4+F1 |  |  |  |  | nerelevantni | CZ_S2 - Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: sloupek; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; Reference: D.1.2.6; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
trasa-průjezdní a průchozí prostor | 0.06 | 2 | yes | ((-642801.563464245,-1062712.11704483,233.38),(-642801.463464245,-1062712.01704483,233.48)) | 9 | trasa-průjezdní a průchozí prostor | Barva_9 | P2 | 191;191;191 |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  | nerelevantni | CZ_I3 - Fáze projektu: PDPS; Název (trasy): Větev OK Starzone; Staničení od: 19.32; Staničení do: 19.44; Označení elementu: průjezdní a průchozí prostor; Označení průjezdného profilu: nerelevantni; Klasifikační systém: nerelevantni; Označení položky: nerelevantni; Označení šablony vlastností: I3+E1+Z1+F1
dopravní značení-svislé dopravní značení | 0.9433 | 2 | yes | ((-642894.232390661,-1062692.14741742,232.2),(-642894.154179251,-1062692.06920601,236)) | 7 | dopravní značení-svislé dopravní značení | Barva_7 | P10 | 255;255;255 |  |  |  | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 113.38 | 113.38 | svislé dopravní značení | dopravní značení | 914981 | I1+S2+E1+Z1+M4+F1 |  |  |  |  | nerelevantni | CZ_S2 - Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: sloupek; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; Reference: D.1.2.6; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 9.764 | 2 | yes | ((-642894.352480754,-1062692.32424813,235),(-642893.389489587,-1062689.99452255,236.9)) | 7 | dopravní značení-svislé dopravní značení | Barva_7 | P10 | 255;255;255 |  |  |  | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 113.46 | 113.46 | svislé dopravní značení | dopravní značení | 914521 | I1+S2+E1+Z1+M4+F1 |  |  |  |  | nerelevantni | CZ_S2 - Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: IS9b; Specifikace: velikost velkoplošná, RA2; Podrobná specifikace: TP 65; Reference: D.1.4.6; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.813672 | 2 | yes | ((-642800.641938863,-1062707.28193065,234.848420117325),(-642800.512260117,-1062706.58747514,235.548420117325)) | 7 | dopravní značení-svislé dopravní značení | Barva_7 | P10 | 255;255;255 |  |  |  | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 19.5 | 19.5 | svislé dopravní značení | dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 |  |  |  |  | nerelevantni | CZ_S2 - Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: B1; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; Reference: D.1.4.6; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.532 | 2 | yes | ((-642800.65415361,-1062707.3171003,234.463757816718),(-642800.509326219,-1062706.62480291,234.813757816718)) | 7 | dopravní značení-svislé dopravní značení | Barva_7 | P10 | 255;255;255 |  |  |  | SO 102 | nerelevantni | PDPS | Komunikace Starzone | OTSKP | 19.5 | 19.5 | svislé dopravní značení | dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 |  |  |  |  | nerelevantni | CZ_S2 - Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: E13; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; Reference: D.1.4.6; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky

# IfcDistributionSystem, Síť-5
Properties - IsReferenceObject: no; IsReferenceStale: no; IsReferenceSubObject: no; IsReferenceValid: no; ShowToolTip: yes; ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: no; IsModifiedGraphics: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no; IsUsed: no; ModifiedPipeNetworkSectionLayerName: C3D-POTRUBI-PR; ModifiedPipePlanLayerName: C3D-POTRUBI; ModifiedPipeProfileLayerName: C3D-PROFIL-POTRUBI; ModifiedStructurePlanLayerName: C3D-SO; ModifiedStructureProfileLayerName: C3D-PROFIL-POTRUBI; PartsListName: Dešťová a splašková kanalizace; PipeNameTemplate: Potrubí-<[Další čítač(CP)]>; PipeNetworkSectionLayerName: C3D-POTRUBI-PR; PipePlanLayerName: C3D-POTRUBI; PipeProfileLayerName: C3D-PROFIL-POTRUBI; ReferenceSurfaceName: pomocny napojeni; StructureNameTemplate: Š<[Další čítač(CP)]>; StructurePlanLayerName: C3D-SO; StructureProfileLayerName: C3D-PROFIL-POTRUBI; DisplayName: Síť; FingerPrint: -1118077474; Name: Síť-5; CloneMeForDragging: yes; Bounds: ((1E+20,1E+20,1E+20),(-1E+20,-1E+20,-1E+20))
Miscellaneous - IsHighlighting: no; NeedsPromoting: no; SupportsBaseCurveCommands: no; SupportsProfileCommands: no; SwappingReferences: no
General - Linetype: ByLayer; LinetypeScale: 1; Visible: yes; ColorIndex: 256; Layer: 100-pomocne; PlotStyleName: ByLayer
Geometry - Closed: no; IsPeriodic: no; IsPlanar: yes
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes

# IfcGeographicElement (13)
In: UnknownName
PredefinedType: TERRAIN
Properties - HasSnapshot: no; IsOutOfDate: no; IsSnapshotOutOfDate: no; IsVolumeSurface: no; Lock: no; DisplayName: Povrch TIN; IsReferenceObject: no; IsReferenceStale: no; IsReferenceSubObject: no; IsReferenceValid: no; ShowToolTip: yes; CloneMeForDragging: no; ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: no; IsModifiedGraphics: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no
Miscellaneous - IsHighlighting: no; NeedsPromoting: no; SupportsBaseCurveCommands: no; SupportsProfileCommands: no; SwappingReferences: no; TypeIcon: (Icon)
General - LayerKey: AeccSurfaceTin; Linetype: ByLayer; LinetypeScale: 1; Visible: yes
Geometry - Closed: no; IsPeriodic: no; IsPlanar: yes
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
CZ_I1 - Označení stavebního objektu: SO 102; Označení podobjektu: nerelevantni; Označení části objektu: nerelevantni; Fáze projektu: PDPS; Název stavebního objektu: Komunikace Starzone; Klasifikační systém: OTSKP
CZ_E1 - Datum zahájení prací: 01.05.2025; Datum dokončení: 30.06.2027; Doba trvání: 790; Datum uvedení do provozu: 01.07.2027; Stavební postup / etapa výstavby: nerelevantni
CZ_F1 - Fáze: trvalý stav
Name | AutoRebuild = IsUsed | FingerPrint | Name | StyleName | Bounds | ColorIndex | Layer | PlotStyleName | Staničení od | Staničení do | Označení elementu | Skupina elementů | Označení položky | Označení šablony vlastností | Materiál | specifikace | podrobná specifikace | CZ_S1, Reference | Textura / barva | Skupina přesnosti | Plocha | Způsob stanovení plochy | Description = Properties, Description
vozovka_chodník-spojovací postřik-1.1 | yes | -821515905 | vozovka_chodník-spojovací postřik-1.1 | postřiky | ((-643100.955451582,-1062816.36181332,232.048243670886),(-642700.538062605,-1062520.97679473,233.24295446696)) | 4 | vozovka_chodník-spojovací postřik | Barva_4 | 31.33 | 231.12 | spojovací postřik | vozovka/chodník | 572213 | I1+S1+E1+Z1+M2+F1 | kat. em. 0,25 kg/m2 | ČSN 73 6129 | nerelevantni | D.1.2.4 | 0;255;255 | P2 | 1784.62 | 3D plocha TIN povrchu
vozovka_chodník-spojovací postřik-2.1 | yes | -1663793108 | vozovka_chodník-spojovací postřik-2.1 | postřiky | ((-643100.985380037,-1062816.43527488,231.996360759494),(-642700.52145036,-1062520.97679473,233.19295446696)) | 4 | vozovka_chodník-spojovací postřik | Barva_4 | 31.33 | 231.12 | spojovací postřik | vozovka/chodník | 572213 | I1+S1+E1+Z1+M2+F1 | kat. em. 0,25 kg/m2 | ČSN 73 6129 | nerelevantni | D.1.2.4 | 0;255;255 | P2 | 1815.86 | 3D plocha TIN povrchu
vozovka_chodník-infiltrační postřik-1.1 | yes | 1519535891 | vozovka_chodník-infiltrační postřik-1.1 | postřiky | ((-643101.037188959,-1062816.56244365,231.933101265823),(-642700.492693028,-1062520.97679473,233.13295446696)) | 4 | vozovka_chodník-infiltrační postřik | Barva_4 | 26.91 | 231.12 | infiltrační postřik | vozovka/chodník | 572123 | I1+S1+E1+Z1+M2+F1 | kat. em 1,0 kg/m2 | ČSN 73 6129 | nerelevantni | D.1.2.4 | 0;255;255 | P2 | 1872.12 | 3D plocha TIN povrchu
zemní práce-pláň | yes | 71278112 | zemní práce-pláň | plan | ((-643101.656165679,-1062817.87508724,231.489044995477),(-642700.196810499,-1062520.97679473,232.78295446696)) | 96 | zemní práce-pláň | Barva_96 | 31.33 | 231.12 | pláň | zemní práce | 18110 | I1+S1+E1+Z1+M2+F1 | nerelevantni | ČSN 73 6133 | nerelevantni | D.1.2.4 | 0;128;0 | P10 | 2454.15 | 3D plocha TIN povrchu
vozovka_chodník-spojovací postřik-1.2 | no | 174611374 | vozovka_chodník-spojovací postřik-1.2 | postřiky | ((-643111.475102947,-1062742.46876919,232.16),(-642890.947933721,-1062520.76359527,232.35)) | 4 | vozovka_chodník-spojovací postřik | Barva_4 | 0 | 0 | spojovací postřik | vozovka/chodník | 572213 | I1+S1+E1+Z1+M2+F1 | kat. em. 0,25 kg/m2 | ČSN 73 6129 | nerelevantni | D.1.2.4 | 0;255;255 | P2 | 71.6077 | 3D plocha TIN povrchu | Popis
vozovka_chodník-spojovací postřik-2.2 | no | -404586239 | vozovka_chodník-spojovací postřik-2.2 | postřiky | ((-643111.47484973,-1062742.46891539,232.11),(-642890.947680504,-1062520.76374146,232.3)) | 4 | vozovka_chodník-spojovací postřik | Barva_4 | 0 | 0 | spojovací postřik | vozovka/chodník | 572213 | I1+S1+E1+Z1+M2+F1 | kat. em. 0,25 kg/m2 | ČSN 73 6129 | nerelevantni | D.1.2.4 | 0;255;255 | P2 | 71.6077 | 3D plocha TIN povrchu | Popis
vozovka_chodník-infiltrační postřik-1.2 | no | -1389332473 | vozovka_chodník-infiltrační postřik-1.2 | postřiky | ((-643111.474502568,-1062742.46885125,232.000000922122),(-642890.947333343,-1062520.76367732,232.190000922122)) | 4 | vozovka_chodník-infiltrační postřik | Barva_4 | 0 | 0 | infiltrační postřik | vozovka/chodník | 572123 | I1+S1+E1+Z1+M2+F1 | kat. em 1,0 kg/m2 | ČSN 73 6129 | nerelevantni | D.1.2.4 | 0;255;255 | P2 | 71.6077 | 3D plocha TIN povrchu | Popis
dopravní značení-vodorovné dopravní značení-V4 | no | -232661572 | dopravní značení-vodorovné dopravní značení-V4 | vdz | ((-643111.475102947,-1062819.39749884,231.295945945946),(-642699.740529358,-1062520.76359527,234.026284774445)) | 7 | dopravní značení-vodorovné dopravní značení | Barva_7 | 22.48 | 230.81 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 |  |  |  |  | 255;255;255 | P10 |  |  | Popis | CZ_S2 - Typ stavebního výrobku: VDZ; Stavební výrobek: V4; Specifikace: barvou; Podrobná specifikace: TP 133; Reference: D.1.2.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M1 - Délka: 230.6; Způsob stanovení délky: Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V1a | no | -1986506213 | dopravní značení-vodorovné dopravní značení-V1a | vdz | ((-643102.835078879,-1062819.39749884,231.295945945946),(-642699.740529358,-1062520.97679473,234.026284774445)) | 7 | dopravní značení-vodorovné dopravní značení | Barva_7 | 22.21 | 215 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 |  |  |  |  | 255;255;255 | P10 |  |  | Popis | CZ_S2 - Typ stavebního výrobku: VDZ; Stavební výrobek: V1a; Specifikace: barvou; Podrobná specifikace: TP 133; Reference: D.1.2.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M1 - Délka: 195.9; Způsob stanovení délky: Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V4 plast | no | 1929671323 | dopravní značení-vodorovné dopravní značení-V4 plast | vdz | ((-643111.475102947,-1062819.39749884,231.295945945946),(-642699.740529358,-1062520.76359527,234.026284774445)) | 7 | dopravní značení-vodorovné dopravní značení | Barva_7 | 22.48 | 230.81 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 |  |  |  |  | 255;255;255 | P10 |  |  | Popis | CZ_M1 - Délka: 230.6; Způsob stanovení délky: Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V1a plast | no | 1986142781 | dopravní značení-vodorovné dopravní značení-V1a plast | vdz | ((-643102.835078879,-1062819.39749884,231.295945945946),(-642699.740529358,-1062520.97679473,234.026284774445)) | 7 | dopravní značení-vodorovné dopravní značení | Barva_7 | 22.21 | 215 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 |  |  |  |  | 255;255;255 | P10 |  |  | Popis | CZ_S2 - Typ stavebního výrobku: VDZ; Stavební výrobek: V1a; Specifikace: plast; Podrobná specifikace: TP 133; Reference: D.1.2.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M1 - Délka: 195.9; Způsob stanovení délky: Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V4 (1) | no | 1946435749 | dopravní značení-vodorovné dopravní značení-V4 (1) | vdz | ((-643111.475102947,-1062819.39749884,231.295945945946),(-642699.740529358,-1062520.76359527,234.026284774445)) | 7 | dopravní značení-vodorovné dopravní značení | Barva_7 | 22.48 | 230.81 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 |  |  |  |  | 255;255;255 | P10 |  |  | Popis | CZ_S2 - Typ stavebního výrobku: VDZ; Stavební výrobek: V4; Specifikace: barvou; Podrobná specifikace: TP 133; Reference: D.1.2.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M1 - Délka: 219.9; Způsob stanovení délky: Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V4 plast (1) | no | -182325654 | dopravní značení-vodorovné dopravní značení-V4 plast (1) | vdz | ((-643111.475102947,-1062819.39749884,231.295945945946),(-642699.740529358,-1062520.76359527,234.026284774445)) | 7 | dopravní značení-vodorovné dopravní značení | Barva_7 | 22.48 | 230.81 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 |  |  |  |  | 255;255;255 | P10 |  |  | Popis | CZ_M1 - Délka: 219.9; Způsob stanovení délky: Délka 3D křivky
